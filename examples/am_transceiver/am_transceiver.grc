options:
  parameters:
    author: Kyttar
    description: DSB-AM transceiver from REAL Kyttar blocks (product modulator + coherent product detector). audio -> Multiply(cos) [passband] -> Multiply(cos) -> LowPass -> Gain -> recovered audio. One shared carrier NCO. Verified corr 1.0. Imports + auto-P&R-routes into placeKYT.
    generate_options: qt_gui
    id: am_transceiver
    output_language: python
    title: DSB-AM transceiver (on-chip, real blocks) — audio in vs recovered
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000.0'
  states: {}
- name: n_samp
  id: variable
  parameters:
    comment: audio burst length
    value: '2048'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT GNURadio-server port
    value: '58950'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: tone2
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio
  id: blocks_add_xx
  parameters:
    comment: input audio (2 tones)
    type: float
  states: {}
- name: thr
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: audio -> chip x16_in
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: lo
  id: kyttar_nco
  parameters:
    amplitude: '0.9'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    offset: '0'
    phase: '0'
    sample_rate: '32000.0'
    waveform: cos
  states: {}
- name: sin_nc
  id: blocks_null_sink
  parameters:
    comment: carrier sin unused (DSB uses cos only)
    type: float
  states: {}
- name: tx_mix
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_mix
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_lpf
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '3000.0'
    decimation: '1'
    device_id: '"kyttar_0"'
    gain: '1'
    interpolation: '1'
    samp_rate: '32000.0'
    transition_width: '2000.0'
    window: hamming
  states: {}
- name: g2
  id: kyttar_gain
  parameters:
    comment: DSB 1/2 -> x2
    device_id: '"kyttar_0"'
    gain: '2'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: recovered audio <- x16_out
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_out"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: in_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    grid: 'True'
    label1: input audio
    name: in_sink
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
    grid_color1: blue
  states: {}
- name: out_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    grid: 'True'
    label1: recovered audio
    name: out_sink
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
    grid_color1: green
  states: {}

connections:
- [tone, '0', audio, '0']
- [tone2, '0', audio, '1']
- [audio, '0', thr, '0']
- [thr, '0', msrc, '0']
- [thr, '0', in_sink, '0']
- [msrc, '0', tx_mix, '0']
- [lo, '0', tx_mix, '1']
- [tx_mix, '0', rx_mix, '0']
- [lo, '0', rx_mix, '1']
- [lo, '1', sin_nc, '0']
- [rx_mix, '0', rx_lpf, '0']
- [rx_lpf, '0', g2, '0']
- [g2, '0', msink, '0']
- [msink, '0', out_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
