options:
  parameters:
    author: Kyttar
    description: DSB-AM TRANSCEIVER from REAL Kyttar blocks. SEPARATE TX chain (audio -> oscMix(fc) -> AM passband, stream 'tx') and SEPARATE RX chain (AM passband -> oscMix(fc) -> LowPass -> Gain -> recovered audio, stream 'rx') sharing ONE chip by stream_id, like the BPSK modem. Verified |corr| ~ 1.0. Imports + auto-P&R-routes into placeKYT.
    generate_options: qt_gui
    id: am_transceiver
    output_language: python
    title: DSB-AM transceiver (on-chip, real blocks) — TX modulate + RX demodulate
  states: {}

blocks:
- name: n_samp
  id: variable
  parameters:
    comment: audio burst length
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000.0'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT GNURadio-server port
    value: '58950'
  states: {}
- name: am_rf
  id: blocks_vector_source_x
  parameters:
    comment: 'RX input: the AM passband (same audio+carrier); finite, no repeat'
    repeat: 'False'
    type: float
    vector: stim.am_passband(n_samp)
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import am_demo_stim as stim
  states: {}
- name: rx_audio
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: recovered audio (RX)
    name: recovered audio (RX)
    size: stim.points(n_samp)
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: rx_f2c
  id: blocks_float_to_complex
  parameters:
    comment: passband -> I (Q=0)
  states: {}
- name: rx_gain
  id: kyttar_gain
  parameters:
    comment: DSB 1/2 -> x2
    device_id: '"kyttar_0"'
    gain: '2'
  states: {}
- name: rx_lpf
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    comment: recover baseband, reject 2*fc
    cutoff_freq: '2000.0'
    device_id: '"kyttar_0"'
    gain: '1'
    samp_rate: '32000.0'
    transition_width: '1000.0'
    window: hamming
  states: {}
- name: rx_mix
  id: kyttar_iq_upconvert
  parameters:
    comment: 'AM demod: y = Re{s*e^jwt} product detect'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    sample_rate: '32000.0'
  states: {}
- name: rx_q0
  id: blocks_null_source
  parameters:
    comment: Q = 0
    type: float
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered audio <- chip x16_out (stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: AM passband -> chip x16_in (shared duplex port, stream 'rx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"rx"'
  states: {}
- name: tx_audio
  id: blocks_vector_source_x
  parameters:
    comment: TX audio (two tones) -> chip (stream 'tx'); finite, no repeat
    repeat: 'False'
    type: float
    vector: stim.tx_audio(n_samp)
  states: {}
- name: tx_f2c
  id: blocks_float_to_complex
  parameters:
    comment: audio -> I (Q=0)
  states: {}
- name: tx_mix
  id: kyttar_iq_upconvert
  parameters:
    comment: 'AM modulate: s = Re{(audio+0j)e^jwt} = audio*cos(fc)'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    sample_rate: '32000.0'
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: AM passband (TX)
    name: AM passband (TX)
    size: stim.points(n_samp)
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: tx_q0
  id: blocks_null_source
  parameters:
    comment: 'Q = 0 (DSB-AM: no quadrature)'
    type: float
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: AM passband <- chip x16_out (stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: TX audio -> chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"tx"'
  states: {}

connections:
- [am_rf, '0', rx_src, '0']
- [rx_f2c, '0', rx_mix, '0']
- [rx_gain, '0', rx_sink, '0']
- [rx_lpf, '0', rx_gain, '0']
- [rx_mix, '0', rx_lpf, '0']
- [rx_q0, '0', rx_f2c, '1']
- [rx_sink, '0', rx_audio, '0']
- [rx_src, '0', rx_f2c, '0']
- [tx_audio, '0', tx_src, '0']
- [tx_f2c, '0', tx_mix, '0']
- [tx_mix, '0', tx_sink, '0']
- [tx_q0, '0', tx_f2c, '1']
- [tx_sink, '0', tx_passband, '0']
- [tx_src, '0', tx_f2c, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
