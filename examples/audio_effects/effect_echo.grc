options:
  parameters:
    author: Lattrex
    description: 'A placed feedforward ECHO (x + 0.5*delay8(x), a single-fire Add join), 0.5 headroom scale, butter(2, 0.15) IIR biquad tone shaping, keep-one-in-2 decimation. Golden: the IDENTICAL stock-GNU-Radio chain within a DERIVED per-block bound.'
    generate_options: qt_gui
    id: effect_echo
    output_language: python
    title: Echo + tone shaping (placed audio effect)
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: audio sample rate
    value: '8000'
  states: {}
- name: sig
  id: variable
  parameters:
    comment: a 330 Hz tone + a faint 2.2 kHz overtone (max 0.55 FS)
    value: '[0.5*math.sin(2*math.pi*330*t/8000) + 0.05*math.sin(2*math.pi*2200*t/8000) for t in range(400)]'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: samples per burst
    value: len(sig)
  states: {}
- name: iir_b
  id: variable
  parameters:
    comment: butter(2, 0.15) numerator
    value: '[0.04125353724172031, 0.08250707448344062, 0.04125353724172031]'
  states: {}
- name: iir_a
  id: variable
  parameters:
    comment: butter(2, 0.15) denominator tail [a1, a2]
    value: '[-1.3489677452527948, 0.5139818942196759]'
  states: {}
- name: fx_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: fx_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"fx"'
  states: {}
- name: echo_delay
  id: kyttar_delay
  parameters:
    device_id: '"kyttar_0"'
    delay: '8'
  states: {}
- name: echo_gain
  id: kyttar_gain
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: echo_add
  id: kyttar_add
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: wet_gain
  id: kyttar_gain
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: biquad
  id: kyttar_iir_biquad
  parameters:
    device_id: '"kyttar_0"'
    b_coeffs: iir_b
    a_coeffs: iir_a
    fftaps: None
    fbtaps: None
    oldstyle: 'False'
  states: {}
- name: decim
  id: kyttar_keep_one_in_n
  parameters:
    device_id: '"kyttar_0"'
    n: '2'
  states: {}
- name: fx_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"fx"'
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    name: '"echo -> biquad -> decimated"'
    size: burst_len//2
    srate: samp_rate
    type: float
    ylabel: level
  states: {}

connections:
- [fx_vec, '0', fx_in, '0']
- [fx_in, '0', echo_add, '0']
- [fx_in, '0', echo_delay, '0']
- [echo_delay, '0', echo_gain, '0']
- [echo_gain, '0', echo_add, '1']
- [echo_add, '0', wet_gain, '0']
- [wet_gain, '0', biquad, '0']
- [biquad, '0', decim, '0']
- [decim, '0', fx_out, '0']
- [fx_out, '0', scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
