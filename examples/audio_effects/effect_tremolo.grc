options:
  parameters:
    author: Lattrex
    description: 'A placed 250 Hz TREMOLO: the trigger-driven complex NCO''s cos rail biased to 0.5 + 0.45*cos and multiplied into the audio (a single-fire Multiply join). Golden: the IDENTICAL stock-GNU-Radio chain (sig_source_f, add_const_ff, multiply_ff) within a DERIVED per-block bound.'
    generate_options: qt_gui
    id: effect_tremolo
    output_language: python
    title: NCO tremolo (placed audio effect)
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: audio sample rate
    value: '8000'
  states: {}
- name: sig
  id: variable
  parameters:
    comment: a 330 Hz tone + a faint 2.2 kHz overtone (max 0.55 FS)
    value: '[0.5*math.sin(2*math.pi*330*t/8000) + 0.05*math.sin(2*math.pi*2200*t/8000) for t in range(400)]'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: samples per burst
    value: len(sig)
  states: {}
- name: fx_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: fx_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"fx"'
  states: {}
- name: trem_nco
  id: kyttar_nco
  parameters:
    device_id: '"kyttar_0"'
    sample_rate: samp_rate
    frequency: '250'
    amplitude: '0.45'
    offset: '0'
    phase: '0'
    waveform: '"cos"'
  states: {}
- name: trem_c2r
  id: kyttar_complex_to_real
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: trem_bias
  id: kyttar_add_const
  parameters:
    device_id: '"kyttar_0"'
    const: '0.5'
  states: {}
- name: trem_mul
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: fx_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"fx"'
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    name: '"250 Hz tremolo (0.05..0.95 gain)"'
    size: burst_len
    srate: samp_rate
    type: float
    ylabel: level
  states: {}

connections:
- [fx_vec, '0', fx_in, '0']
- [fx_in, '0', trem_mul, '0']
- [fx_in, '0', trem_nco, '0']
- [trem_nco, '0', trem_c2r, '0']
- [trem_c2r, '0', trem_bias, '0']
- [trem_bias, '0', trem_mul, '1']
- [trem_mul, '0', fx_out, '0']
- [fx_out, '0', scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
