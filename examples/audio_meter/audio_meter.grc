options:
  parameters:
    author: Lattrex
    description: 'A receiver AUDIO TAIL + S-METER + TRUE-RMS row, three streams full-duplex on one placeKYT chip (shared x16 ports, demuxed by stream tags — the same duplex machinery as the BPSK modem). Stream "audio": DC blocker -> AGC (ref 0.5) -> band-reject 3300..3700 Hz -> power squelch (-25 dB) — the classic voice-channel cleanup. Stream "meter": |x| -> moving average (8) -> 10*log10 dB level (Q15 wire value scaled /64 per the Nlog10 block''s documented HW representation). Stream "rms": blocks.rms_ff — the TRUE RMS level (single-pole power average, then square root, alpha = 0.0625 — exactly representable in Q15 so the chip and GR run the identical time constant); compare its steady tone level (~0.6) against the envelope meter''s rectified average. Golden: the IDENTICAL stock-GNU-Radio chains (dc_blocker_ff, agc_ff, firdes band filters, pwr_squelch_ff, abs_ff, moving_average_ff, nlog10_ff, rms_ff) within a tolerance DERIVED from the per-block verified Q15 error bounds.'
    generate_options: qt_gui
    id: audio_meter
    output_language: python
    title: Receiver audio tail + S-meter (duplex on one array)
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: audio sample rate
    value: '8000'
  states: {}
- name: sig
  id: variable
  parameters:
    comment: 'test signal: a 0.05-DC-offset 1 kHz tone burst, then silence (tone FIRST: a leading silence drives GR agc_ff gain above 1.0, outside the Q15 block envelope)'
    value: '[0.05 + 0.85*math.sin(2*math.pi*1000*t/8000) for t in range(160)] + [0.0]*520'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: samples per stream burst
    value: len(sig)
  states: {}
- name: audio_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: audio_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"audio"'
  states: {}
- name: dcb
  id: kyttar_dc_blocker
  parameters:
    device_id: '"kyttar_0"'
    length: '32'
    long_form: 'False'
  states: {}
- name: agc
  id: kyttar_agc
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.999'
    max_gain: '0.999'
    rate: '0.02'
    reference: '0.3'
  states: {}
- name: brf
  id: kyttar_band_reject_filter
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.999'
    high_cutoff_freq: '3700'
    low_cutoff_freq: '3300'
    samp_rate: samp_rate
    transition_width: '400'
    window: '"hamming"'
  states: {}
- name: sq
  id: kyttar_squelch
  parameters:
    alpha: '0.01'
    db: '-25'
    device_id: '"kyttar_0"'
    gate: 'False'
    ramp: '0'
  states: {}
- name: audio_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"audio"'
  states: {}
- name: audio_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"audio out (DC-blocked, AGC, filtered, squelched)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
  states: {}
- name: meter_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: meter_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"meter"'
  states: {}
- name: env
  id: kyttar_abs
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: avg
  id: kyttar_moving_average
  parameters:
    device_id: '"kyttar_0"'
    length: '8'
    scale: '0.125'
  states: {}
- name: db
  id: kyttar_nlog10
  parameters:
    device_id: '"kyttar_0"'
    k: '0.0'
    n: '10.0'
  states: {}
- name: meter_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"meter"'
  states: {}
- name: meter_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"S-meter (10*log10, scaled /64 on the wire)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
    ymax: '0.2'
  states: {}
- name: rms_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: rms_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rms"'
  states: {}
- name: rms
  id: kyttar_rms
  parameters:
    comment: 'true RMS (rms_ff): power IIR then sqrt; alpha 0.0625 = 2048/32768 exact in Q15'
    alpha: '0.0625'
    device_id: '"kyttar_0"'
  states: {}
- name: rms_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rms"'
  states: {}
- name: rms_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'the true-RMS level: rises to ~0.6 on the tone, decays on the tail silence'
    name: '"True RMS (rms_ff, alpha 0.0625)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
    ymin: '0'
  states: {}

connections:
- [audio_vec, '0', audio_in, '0']
- [audio_in, '0', dcb, '0']
- [dcb, '0', agc, '0']
- [agc, '0', brf, '0']
- [brf, '0', sq, '0']
- [sq, '0', audio_out, '0']
- [audio_out, '0', audio_scope, '0']
- [meter_vec, '0', meter_in, '0']
- [meter_in, '0', env, '0']
- [env, '0', avg, '0']
- [avg, '0', db, '0']
- [db, '0', meter_out, '0']
- [meter_out, '0', meter_scope, '0']
- [rms_vec, '0', rms_in, '0']
- [rms_in, '0', rms, '0']
- [rms, '0', rms_out, '0']
- [rms_out, '0', rms_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
