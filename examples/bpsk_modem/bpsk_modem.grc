options:
  parameters:
    author: Lattrex
    description: 'Full-duplex BPSK modem authored in GNU Radio (GRC-first workflow). The TX chain (PSK symbol mapper -> upsampler -> RRC pulse shaper -> I/Q upconvert) and the coherent RX chain (complex RRC matched filter -> complex Costas loop -> Gardner timing recovery -> BPSK slicer) live on ONE placeKYT array, sharing ONE input port (x16_in) and ONE output port (x16_out): both TX and RX source blocks map to x16_in and both sink blocks map to x16_out (the shared-port duplex). Built from the REAL DSP blocks so it IMPORTS into placeKYT (File -> Import GNURadio Flowgraph): all 8 blocks get placed and the logical nets are recovered; the headless engine.bpsk_modem_demo proves BER 0 on the built bitstream.'
    generate_options: qt_gui
    id: bpsk_modem
    output_language: python
    title: Full-duplex BPSK modem (TX + coherent RX on one array)
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    comment: TX carrier frequency
    value: '8000'
  states: {}
- name: n_bits
  id: variable
  parameters:
    comment: TX bits in the burst
    value: '64'
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: RX symbols in the burst
    value: '120'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TX passband sample rate
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: TX samples per symbol
    value: '4'
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: Complex Costas carrier recovery — placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
    order: '2'
  states: {}
- name: gardner
  id: kyttar_gardner_ted
  parameters:
    comment: Gardner timing recovery — placed on chip
    complex: 'False'
    device_id: '"kyttar_0"'
    ki: '1'
    kp: '3'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import modem_demo_stim as stim
  states: {}
- name: mapper
  id: kyttar_psk_symbol_mapper
  parameters:
    comment: PSK symbol mapper (BPSK) — placed on chip
    device_id: '"kyttar_0"'
    modulation: '"bpsk"'
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC matched filter front end — placed on chip
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: rrc
  id: kyttar_rrc_pulse_shaper
  parameters:
    alpha: '0.35'
    comment: RRC pulse shaper — placed on chip
    device_id: '"kyttar_0"'
    gain: '1.0'
    io_type: complex
    ntaps: '33'
    sampling_freq: '4.0'
    symbol_rate: '1.0'
  states: {}
- name: rx_bits
  id: qtgui_time_sink_x
  parameters:
    comment: recovered bits — from the chip x16_out (stream 'rx')
    name: '"Recovered bits"'
    size: stim.rx_bits_points(n_syms)
    srate: samp_rate
    type: float
    ylabel: bit
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: RX RRC-BPSK I/Q burst (carrier+timing offset); finite, no repeat
    repeat: 'False'
    type: complex
    vector: stim.rx_burst(n_syms)
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bits -> placeKYT chip x16_out (shared duplex port, stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: stim.rx_burst_len(n_syms)
    comment: RX I/Q burst -> placeKYT chip x16_in (shared duplex port, stream 'rx')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: slicer
  id: kyttar_bpsk_slicer
  parameters:
    comment: BPSK slicer (recovered bits) — placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bit stimulus (one finite burst -> EOF dispatches it; no repeat)
    repeat: 'False'
    type: float
    vector: stim.tx_bits(n_bits)
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    comment: TX passband (real) — recovered from the chip x16_out (stream 'tx')
    name: '"TX passband (real)"'
    size: stim.tx_pb_points(n_bits)
    srate: samp_rate
    type: float
    ylabel: amplitude
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: TX passband -> placeKYT chip x16_out (shared duplex port, stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_bits
    comment: TX bits -> placeKYT chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: up
  id: kyttar_upsampler
  parameters:
    comment: Zero-stuff upsampler (sps) — placed on chip
    device_id: '"kyttar_0"'
    io_type: complex
    sps: sps
  states: {}
- name: upc
  id: kyttar_iq_upconvert
  parameters:
    comment: I/Q upconvert to real passband — placed on chip
    device_id: '"kyttar_0"'
    frequency: '8000'
    sample_rate: '32000'
  states: {}
- name: slicer_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}

connections:
- [costas, '0', gardner, '0']
- [gardner, '0', slicer, '0']
- [mapper, '0', up, '0']
- [mf, '0', costas, '0']
- [rrc, '0', upc, '0']
- [rx_iq, '0', rx_src, '0']
- [rx_sink, '0', rx_bits, '0']
- [rx_src, '0', mf, '0']
- [slicer, '0', slicer_b2f, '0']
- [tx_bits, '0', tx_src, '0']
- [tx_sink, '0', tx_passband, '0']
- [tx_src, '0', mapper, '0']
- [up, '0', rrc, '0']
- [upc, '0', tx_sink, '0']
- [slicer_b2f, '0', rx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
