options:
  parameters:
    author: Lattrex
    description: 'A COMPLEX CHANNEL SELECTOR on one placeKYT chip: a real multi-channel input is made complex, a FreqXlatingFIR mixes the 9 kHz channel to baseband through a 9-tap pre-filter, a firdes complex low-pass (gain 0.9, cutoff 1.2 kHz) selects the channel, a complex constant rotates it, and the imag rail egresses. Golden: the IDENTICAL stock-GNU-Radio chain (float_to_complex, freq_xlating_fir_filter_ccf, fir_filter_ccc(firdes.low_pass), multiply_const_cc, complex_to_imag) within a tolerance DERIVED from the per-block verified Q15 error bounds.'
    generate_options: qt_gui
    id: channel_selector
    output_language: python
    title: Complex channel selector (freq-xlating FIR front end)
  states: {}

blocks:
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: RF-ish sample rate
    value: '32000'
  states: {}
- name: sig
  id: variable
  parameters:
    comment: 'two in-channel tones at 8.6/9.4 kHz + interferers at 4 and 14 kHz (sum <= 0.9 FS: Q15 ingress headroom)'
    value: '[0.25*math.sin(2*math.pi*8600*t/32000) + 0.25*math.cos(2*math.pi*9400*t/32000) + 0.2*math.sin(2*math.pi*4000*t/32000) + 0.2*math.sin(2*math.pi*14000*t/32000) for t in range(320)]'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: samples per burst
    value: len(sig)
  states: {}
- name: fxf_taps
  id: variable
  parameters:
    comment: 9-tap hamming-windowed sinc, cutoff 4 kHz, normalized sum|t|=0.98 (FreqXlatingFIR requires sum|taps| <= 1)
    value: '[0.0, 0.018715, 0.099838, 0.226239, 0.290416, 0.226239, 0.099838, 0.018715, 0.0]'
  states: {}
- name: rf_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: sig
  states: {}
- name: rf_in
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rf"'
  states: {}
- name: qzero
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: f2c
  id: kyttar_float_to_complex
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: fxf
  id: kyttar_freq_xlating_fir
  parameters:
    device_id: '"kyttar_0"'
    decimation: '1'
    taps: fxf_taps
    center_freq: '9000'
    sampling_freq: samp_rate
    pipeline_lock: 'False'
  states: {}
- name: clpf
  id: kyttar_complex_low_pass_filter
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.9'
    samp_rate: samp_rate
    cutoff_freq: '1200'
    transition_width: '2500'
    window: '"hamming"'
    beta: '6.76'
  states: {}
- name: rot
  id: kyttar_multiply_const_complex
  parameters:
    device_id: '"kyttar_0"'
    re: '0.6'
    im: '0.35'
  states: {}
- name: conj
  id: kyttar_conjugate
  parameters: {}
  states: {}
- name: c2i
  id: kyttar_complex_to_imag
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: rf_out
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rf"'
  states: {}
- name: scope
  id: qtgui_time_sink_x
  parameters:
    name: '"selected channel (baseband, rotated - imag rail)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
  states: {}

connections:
- [rf_vec, '0', rf_in, '0']
- [rf_in, '0', f2c, '0']
- [qzero, '0', f2c, '1']
- [f2c, '0', fxf, '0']
- [fxf, '0', clpf, '0']
- [clpf, '0', rot, '0']
- [rot, '0', conj, '0']
- [conj, '0', c2i, '0']
- [c2i, '0', rf_out, '0']
- [rf_out, '0', scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
