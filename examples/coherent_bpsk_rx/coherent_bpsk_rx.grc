options:
  parameters:
    author: Lattrex
    description: 'PRODUCTION coherent BPSK RX demo with the RRC matched-filter front end (GRC-first workflow). Built from the REAL DSP blocks so it IMPORTS into placeKYT: ComplexRRCMatchedFilter -> ComplexCostasLoop -> GardnerTimingRecovery -> BPSKSlicer get placed + bus-routed; source/sink -> chip ports. The SAME flowgraph RUNS linked to the placeKYT-hosted chip: Simulation -> Run as GNURadio Server in placeKYT, set server_port below to the printed port, then Execute here. kyttar_source batches the whole I/Q burst through the hosted chip in one RPC. The QT time sinks show the INPUT waveform (top) versus the RECOVERED bits (bottom) — the input-vs-output view.'
    generate_options: qt_gui
    id: coherent_bpsk_rx_mf_demo
    output_language: python
    title: Coherent BPSK RX (RRC matched filter) — input vs recovered bits
  states: {}

blocks:
- name: n_syms
  id: variable
  parameters:
    comment: BPSK symbols in the burst
    value: '160'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: bit_sink
  id: qtgui_time_sink_x
  parameters:
    comment: recovered bits (chip out) — MF + Costas + Gardner RX
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: recovered bit
    name: '"Recovered bits (chip x16_out)"'
    size: '128'
    srate: '1'
    type: float
    ylabel: bit
    ymax: '1.3'
    ymin: '-0.3'
  states: {}
- name: c2f
  id: blocks_complex_to_float
  parameters:
    comment: split I (re) for the input-waveform view
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: Complex Costas carrier recovery (placed on chip)
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
  states: {}
- name: gardner
  id: kyttar_gardner_ted
  parameters:
    comment: Gardner timing recovery (placed on chip)
    device_id: '"kyttar_0"'
    ki: '1'
    kp: '3'
  states: {}
- name: import_stim
  id: import
  parameters:
    comment: RRC BPSK burst generator (carrier + timing offset)
    imports: from gnuradio.kyttar import coherent_demo_stim as stim
  states: {}
- name: input_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input RRC BPSK waveform (in-phase, before the chip)
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: input I
    name: '"Input waveform (RRC BPSK, in-phase)"'
    size: '256'
    srate: '1'
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: RRC matched filter front end (placed on chip)
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: recovered bits <- placeKYT chip x16_out (batch)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: stim.burst_len(n_syms)
    comment: I/Q burst -> placeKYT chip x16_in (batch); fans to MF xi/xq
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: slicer
  id: kyttar_bpsk_slicer
  parameters:
    comment: BPSK slicer (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: RRC BPSK burst (carrier + timing offset) into the chip — REPEAT so the flowgraph never reaches EOF (which would tear down the graph before the QT time sink ever paints); the Kyttar Source dispatches the batch ONCE then passes through, and the Sink re-emits the recovered bits for a stable live plot.
    repeat: 'True'
    type: complex
    vector: stim.burst(n_syms)
  states: {}
- name: slicer_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}

connections:
- [c2f, '0', input_sink, '0']
- [costas, '0', gardner, '0']
- [gardner, '0', slicer, '0']
- [mf, '0', costas, '0']
- [msink, '0', bit_sink, '0']
- [msrc, '0', mf, '0']
- [slicer, '0', slicer_b2f, '0']
- [src, '0', c2f, '0']
- [src, '0', msrc, '0']
- [slicer_b2f, '0', msink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
