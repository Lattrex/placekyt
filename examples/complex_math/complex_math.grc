options:
  parameters:
    author: Lattrex
    description: 'COMPLEX TWO-STREAM ARITHMETIC on one placeKYT array: two analytic complex tones (f_a = 10/256, f_b = 17/256 cyc/sample) drive three placed two-stream blocks — Add CC (a+b: the two tones superpose into a beat envelope), Sub CC (a-b: the same superposition, second tone flipped) and Multiply CC (a*b: THE MIXER — multiplying analytic tones adds their frequencies, one clean tone at f_a+f_b = 27/256). Each block gets its own ingress stream pair (a complex stream cannot fan out on-chip — the fan-out relay is single-rail), and each landing cell pairs the two per-sample packets with its counting join, in any arrival order (the two-external-complex-stream contract). The wiring pattern to copy for any GRC design that combines two complex streams.'
    generate_options: qt_gui
    id: complex_math
    output_language: python
    title: Complex math — AddCC / SubCC / MultiplyCC (two-tone mixer)
  states: {}

blocks:
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import cmath_demo_stim as stim
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate (scope axis only)
    value: '32000'
  states: {}
- name: n_pts
  id: variable
  parameters:
    comment: complex samples per burst
    value: stim.n_samples()
  states: {}
- name: a_vec
  id: blocks_vector_source_x
  parameters:
    comment: 'analytic tone A: exp(+j 2pi (10/256) t), Q15-snapped; finite, no repeat'
    repeat: 'False'
    type: complex
    vector: stim.tone_a()
  states: {}
- name: b_vec
  id: blocks_vector_source_x
  parameters:
    comment: 'analytic tone B: exp(+j 2pi (17/256) t), Q15-snapped; finite, no repeat'
    repeat: 'False'
    type: complex
    vector: stim.tone_b()
  states: {}
- name: a_add_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone A -> chip x16_in (stream ''sum'': Add CC first port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"sum"'
  states: {}
- name: b_add_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone B -> chip x16_in (stream ''b_add'': Add CC second port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"b_add"'
  states: {}
- name: a_sub_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone A -> chip x16_in (stream ''diff'': Sub CC first port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"diff"'
  states: {}
- name: b_sub_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone B -> chip x16_in (stream ''b_sub'': Sub CC second port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"b_sub"'
  states: {}
- name: a_mul_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone A -> chip x16_in (stream ''prod'': Multiply CC first port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"prod"'
  states: {}
- name: b_mul_src
  id: kyttar_source
  parameters:
    burst_len: n_pts
    comment: 'tone B -> chip x16_in (stream ''b_mul'': Multiply CC second port)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    output_words: '"q15"'
    server_port: '58950'
    stream_id: '"b_mul"'
  states: {}
- name: kadd
  id: kyttar_add_cc
  parameters:
    comment: a + b (per-rail saturating Q15 add) — placed on chip
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: ksub
  id: kyttar_sub_cc
  parameters:
    comment: a - b (per-rail saturating Q15 subtract) — placed on chip
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: kmul
  id: kyttar_multiply_cc
  parameters:
    comment: 'a * b (full complex product: yi = ai*bi - aq*bq, yq = ai*bq + aq*bi) — placed on chip'
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: sum_sink
  id: kyttar_sink
  parameters:
    comment: a+b <- chip x16_out (stream 'sum'; I,Q interleaved)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"sum"'
  states: {}
- name: diff_sink
  id: kyttar_sink
  parameters:
    comment: a-b <- chip x16_out (stream 'diff'; I,Q interleaved)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"diff"'
  states: {}
- name: prod_sink
  id: kyttar_sink
  parameters:
    comment: a*b <- chip x16_out (stream 'prod'; I,Q interleaved)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"prod"'
  states: {}
- name: sum_iq2c
  id: epy_block
  parameters:
    _source_code: |
      """Interleaved I,Q floats -> complex pairs (2:1).

      The kyttar sink emits a complex chain's recovered stream as INTERLEAVED
      I,Q float32 (its output port is always float); this embedded block
      reassembles gr_complex for the scope. An embedded block
      (not blocks.float_to_complex) on purpose: stock converter ids are chip-side
      splice markers to the placeKYT importer, and this display glue must stay
      host-side."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self):
              gr.decim_block.__init__(self, name='IQ Pairs to Complex',
                                      in_sig=[np.float32],
                                      out_sig=[np.complex64], decim=2)

          def work(self, input_items, output_items):
              n = len(output_items[0])
              x = input_items[0][:2 * n]
              output_items[0][:] = x[0::2] + 1j * x[1::2]
              return n
    comment: interleaved I,Q floats -> gr_complex (host-side display glue)
  states: {}
- name: diff_iq2c
  id: epy_block
  parameters:
    _source_code: |
      """Interleaved I,Q floats -> complex pairs (2:1).

      The kyttar sink emits a complex chain's recovered stream as INTERLEAVED
      I,Q float32 (its output port is always float); this embedded block
      reassembles gr_complex for the scope. An embedded block
      (not blocks.float_to_complex) on purpose: stock converter ids are chip-side
      splice markers to the placeKYT importer, and this display glue must stay
      host-side."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self):
              gr.decim_block.__init__(self, name='IQ Pairs to Complex',
                                      in_sig=[np.float32],
                                      out_sig=[np.complex64], decim=2)

          def work(self, input_items, output_items):
              n = len(output_items[0])
              x = input_items[0][:2 * n]
              output_items[0][:] = x[0::2] + 1j * x[1::2]
              return n
    comment: interleaved I,Q floats -> gr_complex (host-side display glue)
  states: {}
- name: prod_iq2c
  id: epy_block
  parameters:
    _source_code: |
      """Interleaved I,Q floats -> complex pairs (2:1).

      The kyttar sink emits a complex chain's recovered stream as INTERLEAVED
      I,Q float32 (its output port is always float); this embedded block
      reassembles gr_complex for the scope. An embedded block
      (not blocks.float_to_complex) on purpose: stock converter ids are chip-side
      splice markers to the placeKYT importer, and this display glue must stay
      host-side."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self):
              gr.decim_block.__init__(self, name='IQ Pairs to Complex',
                                      in_sig=[np.float32],
                                      out_sig=[np.complex64], decim=2)

          def work(self, input_items, output_items):
              n = len(output_items[0])
              x = input_items[0][:2 * n]
              output_items[0][:] = x[0::2] + 1j * x[1::2]
              return n
    comment: interleaved I,Q floats -> gr_complex (host-side display glue)
  states: {}
- name: in_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'the two source tones (host side): A at 10/256, B at 17/256 cyc/sample'
    label1: tone A
    label2: ''
    label3: tone B
    label4: ''
    name: '"Input tones A (10/256) and B (17/256)"'
    nconnections: '2'
    size: n_pts - 16
    srate: samp_rate
    type: complex
    ylabel: level
    ymax: '0.6'
    ymin: '-0.6'
  states: {}
- name: sum_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'a + b from the chip: the two tones superpose (beat envelope at (17-10)/256)'
    name: '"Add CC: a + b (chip) — two-tone beat"'
    size: n_pts
    srate: samp_rate
    type: complex
    ylabel: level
  states: {}
- name: diff_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'a - b from the chip: the same beat with the B tone phase-flipped'
    name: '"Sub CC: a - b (chip)"'
    size: n_pts
    srate: samp_rate
    type: complex
    ylabel: level
  states: {}
- name: prod_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'a * b from the chip: THE MIXER — one clean tone at f_a + f_b = 27/256 cyc/sample'
    name: '"Multiply CC: a * b (chip) — the mixer, tone at 27/256"'
    size: n_pts
    srate: samp_rate
    type: complex
    ylabel: level
    ymax: '0.3'
    ymin: '-0.3'
  states: {}

connections:
- [a_vec, '0', a_add_src, '0']
- [a_vec, '0', a_sub_src, '0']
- [a_vec, '0', a_mul_src, '0']
- [b_vec, '0', b_add_src, '0']
- [b_vec, '0', b_sub_src, '0']
- [b_vec, '0', b_mul_src, '0']
- [a_vec, '0', in_scope, '0']
- [b_vec, '0', in_scope, '1']
- [a_add_src, '0', kadd, '0']
- [a_sub_src, '0', ksub, '0']
- [a_mul_src, '0', kmul, '0']
- [b_add_src, '0', kadd, '1']
- [b_sub_src, '0', ksub, '1']
- [b_mul_src, '0', kmul, '1']
- [kadd, '0', sum_sink, '0']
- [ksub, '0', diff_sink, '0']
- [kmul, '0', prod_sink, '0']
- [sum_sink, '0', sum_iq2c, '0']
- [diff_sink, '0', diff_iq2c, '0']
- [prod_sink, '0', prod_iq2c, '0']
- [sum_iq2c, '0', sum_scope, '0']
- [diff_iq2c, '0', diff_scope, '0']
- [prod_iq2c, '0', prod_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
