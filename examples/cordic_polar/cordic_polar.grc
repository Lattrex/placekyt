options:
  parameters:
    author: Lattrex
    description: 'CORDIC polar decomposition on the Kyttar array: ONE complex signal (an amplitude-modulated rotating phasor) split into two placed CORDIC chains — Complex To Mag recovers the AM ENVELOPE, Complex To Arg recovers the PHASE RAMP — each overlaid on the stock GNU Radio reference block so the chip and GR traces sit on top of each other. Both chains share the chip via the stream-id duplex (streams "mag" / "arg" on x16_in/x16_out). The Arg chain emits HALF-TURN units (word/32768*pi rad); the stock reference is scaled by 1/pi so the traces align. Run as GNURadio Server in placeKYT (port 58950), then Execute here.'
    generate_options: qt_gui
    id: cordic_polar
    output_language: python
    title: Kyttar CORDIC polar — on-chip magnitude + phase vs stock GNU Radio
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    comment: samples per dispatched burst
    value: '256'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: iq_stim
  id: variable
  parameters:
    comment: 'AM''d rotating phasor: envelope 0.25..0.80 at 2 cyc/burst, phase ramp 10 cyc/burst — mag shows the envelope, arg shows the sawtooth'
    value: '[(0.25+0.55*(0.5+0.5*__import__(''math'').sin(2*3.141592653589793*2*n/burst_len)))*complex(__import__(''math'').cos(2*3.141592653589793*10*n/burst_len),__import__(''math'').sin(2*3.141592653589793*10*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: src_mag
  id: blocks_vector_source_x
  parameters:
    comment: stimulus for the MAG stream (repeat for a stable live plot)
    repeat: 'True'
    type: complex
    vector: iq_stim
  states: {}
- name: src_arg
  id: blocks_vector_source_x
  parameters:
    comment: stimulus for the ARG stream (same signal, its own stream)
    repeat: 'True'
    type: complex
    vector: iq_stim
  states: {}
- name: ksrc_mag
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: I/Q burst -> chip x16_in (stream 'mag')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    output_words: '"q15"'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"mag"'
  states: {}
- name: ksrc_arg
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: I/Q burst -> chip x16_in (stream 'arg')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    output_words: '"q15"'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"arg"'
  states: {}
- name: cmag
  id: kyttar_complex_to_mag
  parameters:
    block_name: '""'
    comment: CORDIC vectoring |x+jy| (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: carg
  id: kyttar_complex_to_arg
  parameters:
    block_name: '""'
    comment: CORDIC vectoring atan2 in half-turns (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: ksink_mag
  id: kyttar_sink
  parameters:
    comment: chip envelope <- x16_out (stream 'mag')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"mag"'
  states: {}
- name: ksink_arg
  id: kyttar_sink
  parameters:
    comment: chip phase (half-turns) <- x16_out (stream 'arg')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"arg"'
  states: {}
- name: ref_mag
  id: blocks_complex_to_mag
  parameters:
    comment: stock GNU Radio reference envelope
  states: {}
- name: ref_arg
  id: blocks_complex_to_arg
  parameters:
    comment: stock GNU Radio reference phase (radians)
  states: {}
- name: ref_arg_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: radians -> half-turns (1/pi), matching the chip's angle units
    const: '0.3183098861837907'
    type: float
  states: {}
- name: time_mag
  id: qtgui_time_sink_x
  parameters:
    comment: stock GR envelope (blue) vs Kyttar CORDIC envelope (red)
    grid: 'True'
    label1: GNU Radio |x|
    label2: Kyttar CORDIC |x|
    name: '"Envelope: stock GNU Radio vs on-chip CORDIC"'
    nconnections: '2'
    size: '256'
    srate: '1'
    type: float
    width1: '2'
    ylabel: magnitude
    ymax: '1.0'
    ymin: '0.0'
  states: {}
- name: time_arg
  id: qtgui_time_sink_x
  parameters:
    comment: stock GR phase/pi (blue) vs Kyttar CORDIC half-turns (red)
    grid: 'True'
    label1: GNU Radio arg/pi
    label2: Kyttar CORDIC arg (half-turns)
    name: '"Phase: stock GNU Radio vs on-chip CORDIC (half-turn units)"'
    nconnections: '2'
    size: '256'
    srate: '1'
    type: float
    width1: '2'
    ylabel: half-turns
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [src_mag, '0', ksrc_mag, '0']
- [src_mag, '0', ref_mag, '0']
- [ksrc_mag, '0', cmag, '0']
- [cmag, '0', ksink_mag, '0']
- [ksink_mag, '0', time_mag, '1']
- [ref_mag, '0', time_mag, '0']
- [src_arg, '0', ksrc_arg, '0']
- [src_arg, '0', ref_arg, '0']
- [ksrc_arg, '0', carg, '0']
- [carg, '0', ksink_arg, '0']
- [ksink_arg, '0', time_arg, '1']
- [ref_arg, '0', ref_arg_scale, '0']
- [ref_arg_scale, '0', time_arg, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
