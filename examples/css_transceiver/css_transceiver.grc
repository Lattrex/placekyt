options:
  parameters:
    author: Lattrex
    description: 'CSS (chirp spread spectrum) receiver on one placeKYT array. The WHOLE receive spine is placed on the chip: dechirp (conjugate chirp mixer) -> 16-point streaming FFT -> bin power -> the alignment Delay(1) -> framewise argmax. One continuous burst carries the message ''KYTTAR CSS'' twice: segment A at +10 dB SNR decodes exactly, segment B at -10 dB is the on-chip negative control and collapses. The decode map is s = brev4(bin index) because FFT16 emits bins in bit-reversed order. The transmitter and channel are host-side numpy (bit-exact to the TX blocks'' own chip-verified goldens) - this is an RX example and does not claim a transmitter on the chip.'
    generate_options: qt_gui
    id: css_transceiver
    output_language: python
    title: CSS receiver - chirp spread spectrum on one placeKYT array
  states: {}

blocks:
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import css_demo_stim as stim
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate (scope axis only)
    value: '32000'
  states: {}
- name: n_css
  id: variable
  parameters:
    comment: samples per chirp symbol == FFT size == alphabet
    value: '16'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: complex samples in the whole shipped burst (both segments)
    value: stim.burst_len()
  states: {}
- name: n_words
  id: variable
  parameters:
    comment: index words the chip emits (the spine is n:1)
    value: stim.n_out_words()
  states: {}
- name: tx_syms
  id: variable
  parameters:
    comment: the transmitted symbols of ONE segment (preamble + message) - the reference the display block locks to the decoded stream
    value: stim.framed_symbols()[:stim.n_data_symbols()]
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: 'the CSS burst as the radio sees it: the framed message as cyclic-shifted up-chirps, segment A at +10 dB SNR then segment B at -10 dB (the on-chip negative control). Repeating, so the scopes keep painting.'
    repeat: 'True'
    type: complex
    vector: stim.rx_burst()
  states: {}
- name: input_scope
  id: qtgui_time_sink_x
  parameters:
    comment: the received chirp burst (I and Q). Each 16-sample frame is one cyclic-shifted up-chirp; the shift IS the symbol.
    name: '"RF burst — CSS up-chirps (A: +10 dB, B: -10 dB)"'
    size: burst_len // 2
    srate: samp_rate
    type: complex
    ylabel: level
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: the burst -> chip x16_in (stream 'rx'). complex_in=complex, so the recovered stream comes back as RAW word floats — the argmax index plots directly, no q15 rescale.
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: dechirp
  id: kyttar_conj_chirp_mixer
  parameters:
    comment: DECHIRP — multiply by the conjugate reference up-chirp; a symbol chirp becomes a constant tone (placed on chip)
    device_id: '"kyttar_0"'
    n: n_css
  states: {}
- name: fft
  id: kyttar_fft16
  parameters:
    comment: 16-point streaming FFT — the tone lands in ONE bin (placed on chip; output order is bit-reversed)
    device_id: '"kyttar_0"'
  states: {}
- name: magsq
  id: kyttar_complex_to_mag_squared
  parameters:
    comment: bin POWER (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: align
  id: kyttar_delay
  parameters:
    comment: THE ALIGNMENT DELAY — FFT16's latency is 15 == -1 (mod 16), so argmax frames would STRADDLE two FFT frames. This ONE sample lands every frame on exactly one FFT frame. Remove it and the decode breaks (placed on chip).
    delay: '1'
    device_id: '"kyttar_0"'
  states: {}
- name: argmax
  id: kyttar_bin_argmax
  parameters:
    comment: the winning bin of each 16-bin frame — the detected symbol (placed on chip)
    device_id: '"kyttar_0"'
    n: n_css
  states: {}
- name: idx_s2f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bin indices <- chip x16_out (stream 'rx'). server_repeat loops the genuine one-batch result so the scopes keep painting (GNU Radio strands the tail of a finite stream).
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: bin_scope
  id: qtgui_time_sink_x
  parameters:
    comment: the RAW argmax index straight off the chip. Bins come out in FFT16's bit-reversed order, so this is not yet the symbol.
    name: '"Chip output — winning FFT bin (raw index 0..15)"'
    size: n_words
    srate: samp_rate
    type: float
    ylabel: bin index
    ymax: '16'
    color1: green
  states: {}
- name: bin_to_sym
  id: epy_block
  parameters:
    _source_code: |
      # SPDX-License-Identifier: GPL-3.0-or-later
      """CSS DEMOD MAP + SEGMENT SPLITTER — what the DECODED-vs-TRANSMITTED scope draws.

      Two jobs, and the second one is why this block exists at all.

      **1. The decode map.** The on-chip FFT16 emits its 16 bins in bit-reversed (DIF)
      order, so the winning bin index ``i`` is not the symbol: the symbol is
      ``s = brev4(i)`` — the 4-bit reversal of the index.

      **2. The reference rides the SAME stream as the decode.** This is the
      load-bearing part. The shipped burst is TWO segments through one chain —
      segment A at +10 dB (which decodes exactly) and segment B at -10 dB (the
      on-chip NEGATIVE CONTROL, which must not). Displaying that correctly is not a
      matter of taste; two earlier display defects made a perfect decode look broken:

        * **PHASE DRIFT.** The old flowgraph drew the transmitted reference from a
          SEPARATE ``vector_source`` on channel 1 of the scope. That source free-runs
          while the chip's stream is gated by the simulator's batch turnaround —
          measured at **+27.9 % more items over the same run**. A QT time_sink pulls
          the same count from both channels, so the red reference SLID against the
          blue decode. Once offset by as few as 3 items, **22 of segment A's 24
          perfectly-decoded symbols render as mismatches**. The plot smeared while the
          chip was bit-exact.
        * **A/B CONFLATION.** Even at zero offset, segment B's intentional garbage was
          drawn on the same axis as segment A's perfect lock, with nothing to tell a
          viewer which half was which. 17 of 50 plotted points disagreed *by design*
          and the plot did not say so.

      The cure for both: derive the reference HERE, from the item index of the very
      stream being decoded, and split the two segments onto their OWN channels. The
      reference cannot drift from the decode because it is generated per item from the
      same counter, and segment A's lock is never overplotted by segment B's collapse.

      Frame layout (one batch = ``n_words`` items, ``seg_words`` per segment)::

          word 0            the framing-latency word — carries no data symbol
          word 1 .. n_data  symbol f arrives in word f+1

      so a segment's reference trace is ``[BLANK] + preamble + message symbols``.

      Outputs (all four are the SAME length and the SAME phase — plot them together):

        out0  segment A decoded  (chip)          blank outside segment A
        out1  segment A transmitted (reference)  blank outside segment A
        out2  segment B decoded  (chip)          blank outside segment B
        out3  segment B transmitted (reference)  blank outside segment B

      ``BLANK`` is NaN: GNU Radio's time sink leaves a gap rather than drawing a
      misleading 0 or -1, so each pair occupies only its own half of the sweep.
      """
      import numpy as np
      from gnuradio import gr

      # brev4: 4-bit reversal, the FFT16 DIF output-order map (index -> symbol).
      _BREV4 = [((i & 1) << 3) | ((i & 2) << 1) | ((i & 4) >> 1) | ((i & 8) >> 3)
                for i in range(16)]

      BLANK = float("nan")


      class blk(gr.sync_block):
          """n        = samples per chirp symbol == FFT size == alphabet (16)
          tx_syms     = the transmitted symbol sequence for ONE segment, on the output
                        word grid (element 0 is the framing-latency word)
          seg_words   = index words per segment
          """

          def __init__(self, n=16, tx_syms=(), seg_words=25):
              gr.sync_block.__init__(
                  self, name='CSS Bin -> Symbol + A/B split',
                  in_sig=[np.float32],
                  out_sig=[np.float32, np.float32, np.float32, np.float32])
              self.n = int(n)
              self.seg_words = int(seg_words)
              # The per-segment reference trace, on the output word grid. Element 0 is
              # the framing-latency word (no data symbol) and is drawn BLANK.
              ref = [BLANK] + [float(s) for s in tx_syms]
              ref = ref[:self.seg_words]
              ref += [BLANK] * (self.seg_words - len(ref))
              self._ref = np.asarray(ref, dtype=np.float32)
              # Item counter modulo the whole two-segment batch — this is what keeps
              # the reference locked to the decode (see the module docstring).
              self._k = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              nout = len(x)
              w = self.seg_words
              period = 2 * w

              idx = np.rint(x.astype(np.float64)).astype(np.int64) & 0xFFFF
              sym = np.full(nout, BLANK, dtype=np.float32)
              good = (idx >= 0) & (idx < 16)
              sym[good] = [float(_BREV4[i]) for i in idx[good]]

              # Position of every item within the two-segment batch.
              pos = (np.arange(nout, dtype=np.int64) + self._k) % period
              in_a = pos < w
              in_b = ~in_a
              ref = self._ref[pos % w]

              # A word the reference does not cover carries no data symbol (word 0 is
              # the framing-latency word). Blank the DECODE there too — plotting it
              # would put a lone unmatched point on an otherwise exact overlay and
              # invite precisely the "one symbol is wrong" question it is not.
              drawn = ~np.isnan(ref)
              sym = np.where(drawn, sym, BLANK)

              a_dec, a_ref, b_dec, b_ref = (output_items[i] for i in range(4))
              a_dec[:nout] = np.where(in_a, sym, BLANK)
              a_ref[:nout] = np.where(in_a, ref, BLANK)
              b_dec[:nout] = np.where(in_b, sym, BLANK)
              b_ref[:nout] = np.where(in_b, ref, BLANK)

              self._k = (self._k + nout) % period
              return nout
    comment: s = brev4(index) AND the A/B split. The transmitted reference is generated HERE, from the same stream's item index, so it CANNOT drift against the decode (a separate vector_source ran 27.9% fast and smeared the plot). Segment A and segment B get their own channel pair.
    n: n_css
    tx_syms: tx_syms
    seg_words: seg_words
  states: {}
- name: sym_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'BOTH segments, each against its OWN reference, all four traces phase-locked to the chip stream. A: blue decoded sits exactly on the cyan reference. B: red decoded scatters off the orange reference - the on-chip negative control.'
    name: '"DECODED vs TRANSMITTED - segment A (+10 dB) locks | segment B (-10 dB) collapses"'
    nconnections: '4'
    size: n_words
    srate: samp_rate
    type: float
    ylabel: symbol
    ymax: '16'
    label1: A (+10 dB) decoded - chip
    marker1: '0'
    style1: '0'
    color2: cyan
    label2: A (+10 dB) transmitted
    marker2: '1'
    style2: '0'
    color3: red
    label3: B (-10 dB) decoded - chip
    marker3: '0'
    style3: '0'
    color4: dark red
    label4: B (-10 dB) transmitted
    marker4: '1'
    style4: '0'
  states: {}
- name: seg_words
  id: variable
  parameters:
    comment: index words per segment (A and B are the same length)
    value: stim.n_out_words() // 2
  states: {}

connections:
- [rx_iq, '0', input_scope, '0']
- [rx_iq, '0', rx_src, '0']
- [rx_src, '0', dechirp, '0']
- [dechirp, '0', fft, '0']
- [fft, '0', magsq, '0']
- [magsq, '0', align, '0']
- [align, '0', argmax, '0']
- [argmax, '0', idx_s2f, '0']
- [idx_s2f, '0', rx_sink, '0']
- [rx_sink, '0', bin_scope, '0']
- [rx_sink, '0', bin_to_sym, '0']
- [bin_to_sym, '0', sym_scope, '0']
- [bin_to_sym, '1', sym_scope, '1']
- [bin_to_sym, '2', sym_scope, '2']
- [bin_to_sym, '3', sym_scope, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
