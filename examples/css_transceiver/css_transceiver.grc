options:
  parameters:
    author: Lattrex
    description: 'CSS (chirp spread spectrum) receiver on one placeKYT array. The WHOLE receive spine is placed on the chip: dechirp (conjugate chirp mixer) -> 16-point streaming FFT -> bin power -> the alignment Delay(1) -> framewise argmax. One continuous burst carries the message ''KYTTAR CSS'' twice: segment A at +10 dB SNR decodes exactly, segment B at -10 dB is the on-chip negative control and collapses. The decode map is s = brev4(bin index) because FFT16 emits bins in bit-reversed order. The transmitter and channel are host-side numpy (bit-exact to the TX blocks'' own chip-verified goldens) - this is an RX example and does not claim a transmitter on the chip.'
    generate_options: qt_gui
    id: css_transceiver
    output_language: python
    title: CSS receiver - chirp spread spectrum on one placeKYT array
  states: {}

blocks:
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import css_demo_stim as stim
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate (scope axis only)
    value: '32000'
  states: {}
- name: n_css
  id: variable
  parameters:
    comment: samples per chirp symbol == FFT size == alphabet
    value: '16'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: complex samples in the whole shipped burst (both segments)
    value: stim.burst_len()
  states: {}
- name: n_words
  id: variable
  parameters:
    comment: index words the chip emits (the spine is n:1)
    value: stim.n_out_words()
  states: {}
- name: tx_syms
  id: variable
  parameters:
    comment: the transmitted symbol sequence, repeated for both segments (the red reference trace)
    value: stim.display_symbols()
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: 'the CSS burst as the radio sees it: the framed message as cyclic-shifted up-chirps, segment A at +10 dB SNR then segment B at -10 dB (the on-chip negative control). Repeating, so the scopes keep painting.'
    repeat: 'True'
    type: complex
    vector: stim.rx_burst()
  states: {}
- name: input_scope
  id: qtgui_time_sink_x
  parameters:
    comment: the received chirp burst (I and Q). Each 16-sample frame is one cyclic-shifted up-chirp; the shift IS the symbol.
    name: '"RF burst — CSS up-chirps (A: +10 dB, B: -10 dB)"'
    size: burst_len // 2
    srate: samp_rate
    type: complex
    ylabel: level
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: the burst -> chip x16_in (stream 'rx'). complex_in=complex, so the recovered stream comes back as RAW word floats — the argmax index plots directly, no q15 rescale.
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: dechirp
  id: kyttar_conj_chirp_mixer
  parameters:
    comment: DECHIRP — multiply by the conjugate reference up-chirp; a symbol chirp becomes a constant tone (placed on chip)
    device_id: '"kyttar_0"'
    n: n_css
  states: {}
- name: fft
  id: kyttar_fft16
  parameters:
    comment: 16-point streaming FFT — the tone lands in ONE bin (placed on chip; output order is bit-reversed)
    device_id: '"kyttar_0"'
  states: {}
- name: magsq
  id: kyttar_complex_to_mag_squared
  parameters:
    comment: bin POWER (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: align
  id: kyttar_delay
  parameters:
    comment: THE ALIGNMENT DELAY — FFT16's latency is 15 == -1 (mod 16), so argmax frames would STRADDLE two FFT frames. This ONE sample lands every frame on exactly one FFT frame. Remove it and the decode breaks (placed on chip).
    delay: '1'
    device_id: '"kyttar_0"'
  states: {}
- name: argmax
  id: kyttar_bin_argmax
  parameters:
    comment: the winning bin of each 16-bin frame — the detected symbol (placed on chip)
    device_id: '"kyttar_0"'
    n: n_css
  states: {}
- name: idx_s2f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bin indices <- chip x16_out (stream 'rx'). server_repeat loops the genuine one-batch result so the scopes keep painting (GNU Radio strands the tail of a finite stream).
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: bin_scope
  id: qtgui_time_sink_x
  parameters:
    comment: the RAW argmax index straight off the chip. Bins come out in FFT16's bit-reversed order, so this is not yet the symbol.
    name: '"Chip output — winning FFT bin (raw index 0..15)"'
    size: n_words
    srate: samp_rate
    type: float
    ylabel: bin index
    ymax: '16'
    color1: green
  states: {}
- name: bin_to_sym
  id: epy_block
  parameters:
    _source_code: |
      # SPDX-License-Identifier: GPL-3.0-or-later
      """CSS DEMOD MAP — turn the chip's raw argmax BIN INDEX into the SYMBOL.

      The on-chip FFT16 emits its 16 bins in bit-reversed (DIF) order, so the
      winning bin index i is not the symbol: the symbol is ``s = brev4(i)`` — the
      4-bit reversal of the index. This block applies exactly that map, and nothing
      else, to the raw index words the kyttar sink delivers.

      An embedded block on purpose: this is host-side DISPLAY glue (the same map
      the example's gate applies), not chip DSP — stock converter ids are chip-side
      splice markers to the placeKYT importer, so a plain converter cannot be used
      here.

      in0  = the kyttar sink output. A complex-input chain egresses RAW word floats,
             so each item is already the integer index 0..15 (no q15 rescale).
      out0 = the decoded symbol s = brev4(index), as a float 0..15 — plot it
             against the transmitted symbol sequence.
      """
      import numpy as np
      from gnuradio import gr

      # brev4: 4-bit reversal, the FFT16 DIF output-order map (index -> symbol).
      _BREV4 = [((i & 1) << 3) | ((i & 2) << 1) | ((i & 4) >> 1) | ((i & 8) >> 3)
                for i in range(16)]


      class blk(gr.sync_block):
          def __init__(self, n=16):
              gr.sync_block.__init__(self, name='CSS Bin -> Symbol (brev4)',
                                     in_sig=[np.float32], out_sig=[np.float32])
              self.n = int(n)

          def work(self, input_items, output_items):
              x = input_items[0]
              idx = np.rint(x.astype(np.float64)).astype(np.int64) & 0xFFFF
              out = np.zeros(len(idx), dtype=np.float32)
              for k, i in enumerate(idx):
                  out[k] = float(_BREV4[i]) if 0 <= i < 16 else -1.0
              output_items[0][:len(out)] = out
              return len(out)
    comment: s = brev4(index) — FFT16 emits bins bit-reversed, so the index must be 4-bit-reversed to become the symbol
    n: n_css
  states: {}
- name: tx_ref
  id: blocks_vector_source_x
  parameters:
    comment: the TRANSMITTED symbol sequence (host reference) — the red trace the chip's decoded symbols must sit on top of in segment A, and visibly miss in segment B
    repeat: 'True'
    type: float
    vector: tx_syms
  states: {}
- name: sym_scope
  id: qtgui_time_sink_x
  parameters:
    comment: blue = the chip's decoded symbol s = brev4(bin); red = what was transmitted. Segment A (+10 dB) matches exactly; segment B (-10 dB) is the on-chip negative control and does not.
    name: '"DECODED SYMBOL vs TRANSMITTED — A locks, B collapses"'
    nconnections: '2'
    size: n_words
    srate: samp_rate
    type: float
    ylabel: symbol
    ymax: '16'
    label1: decoded symbol (chip)
    marker1: '0'
    style1: '0'
    label2: transmitted symbol
    marker2: '1'
    style2: '0'
  states: {}

connections:
- [rx_iq, '0', input_scope, '0']
- [rx_iq, '0', rx_src, '0']
- [rx_src, '0', dechirp, '0']
- [dechirp, '0', fft, '0']
- [fft, '0', magsq, '0']
- [magsq, '0', align, '0']
- [align, '0', argmax, '0']
- [argmax, '0', idx_s2f, '0']
- [idx_s2f, '0', rx_sink, '0']
- [rx_sink, '0', bin_scope, '0']
- [rx_sink, '0', bin_to_sym, '0']
- [bin_to_sym, '0', sym_scope, '0']
- [tx_ref, '0', sym_scope, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
