options:
  parameters:
    author: Lattrex
    description: 'A FULL CW (Morse) TRANSCEIVER on one placeKYT chip: TX (chars -> SRAM-backed keyer -> ITU-R keyed envelope) and RX (keyed audio -> Abs envelope detector -> STREAMING fixed-unit SRAM-backed Morse decoder -> chars) duplexed by stream tags, the keyer ROM and the reverse-Morse LUT (at addr_base 12288) SHARING the single SRAM panel. The decoder is a skimmer locked to the keyer''s configured unit (samples_per_dot == unit_samples). Word gaps decode as character boundaries (no spaces - documented v1 cell-budget limit); terminate an RX burst with an EOT blip. PER-SAMPLE PACED (the panel contract).'
    generate_options: qt_gui
    id: cw_transceiver
    output_language: python
    title: CW full transceiver (duplex, shared SRAM panel)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: scope display rate (samples/s of the keyed envelope)
    value: '8000'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: unit
  id: variable
  parameters:
    comment: dot length in samples (keyer samples_per_dot == decoder unit_samples)
    value: '8'
  states: {}
- name: msg
  id: variable
  parameters:
    comment: TX chars (space -> 0, the keyer's word-gap code)
    value: '[ord(c) if c != '' '' else 0 for c in ''CQ CQ DE KYTTAR'']'
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: len(msg)
  states: {}
- name: rx_sig
  id: variable
  parameters:
    comment: keyed CW envelope for 'RST 599 73' (rect, unit samples/dot, 1-unit element gaps, 3-unit letter gaps) + tail silence + the EOT blip (>=2*unit silence then >=1 ON sample) that flushes the last letter. Replace with a live keyed-audio feed.
    value: sum([sum([[1.0]*(unit if e=='.' else 3*unit)+[0.0]*unit for e in m],[])+[0.0]*2*unit for m in ['.-.','...','-','.....','----.','----.','--...','...--']],[]) + [0.0]*3*unit + [0.9]*2
  states: {}
- name: rx_burst_len
  id: variable
  parameters:
    value: len(rx_sig)
  states: {}
- name: msg_src
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: msg
  states: {}
- name: b2f_in
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: to_raw
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: f2b
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: keyer
  id: kyttar_cw_keyer
  parameters:
    device_id: '"kyttar_0"'
    wpm: '20'
    samples_per_dot: unit
    edge_samples: '2'
    charset: None
    panel_hop: '1'
    emit_hop: '1'
    emit_dest: '0'
    emit_entry: '1'
    done_entry: '0'
    read_wr_desc: '0'
    read_jp_desc: '0'
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"TX keyed envelope (ITU-R Morse)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
  states: {}
- name: rx_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: rx_sig
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: rx_burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: env
  id: kyttar_abs
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: cwdec
  id: kyttar_cw_decoder
  parameters:
    device_id: '"kyttar_0"'
    threshold: '0.3'
    panel_hop: '1'
    emit_hop: '1'
    emit_dest: '25'
    emit_entry: '1'
    unit_samples: unit
    read_addr_hop: '1'
    read_dest: '5'
    read_entry: '1'
    read_wr_desc: '0'
    read_jp_desc: '0'
    out_dest: '25'
    emit_jump_entry: None
    run_dest: '25'
    run_entry: '1'
    addr_base: '16384'
  states: {}
- name: rx_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: rx_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"RX decoded chars (ASCII codes)"'
    size: '8'
    srate: samp_rate
    type: float
    ylabel: level
    ymax: '128'
    ymin: '0'
  states: {}
- name: rx_chars
  id: blocks_multiply_const_vxx
  parameters:
    comment: kyttar.sink emits the chip stream as q15/32768 floats; restore the raw word value for display
    const: '32768.0'
    type: float
  states: {}

connections:
- [msg_src, '0', b2f_in, '0']
- [b2f_in, '0', to_raw, '0']
- [to_raw, '0', tx_src, '0']
- [tx_src, '0', f2b, '0']
- [f2b, '0', keyer, '0']
- [keyer, '0', tx_sink, '0']
- [tx_sink, '0', tx_scope, '0']
- [rx_vec, '0', rx_src, '0']
- [rx_src, '0', env, '0']
- [env, '0', cwdec, '0']
- [cwdec, '0', rx_b2f, '0']
- [rx_b2f, '0', rx_sink, '0']
- [rx_sink, '0', rx_chars, '0']
- [rx_chars, '0', rx_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
