options:
  parameters:
    author: Lattrex
    description: 'A scrambled DATA-LINK LOOPBACK entirely on the placeKYT chip: payload bytes -> unpack to bits (MSB first) -> bitwise NOT -> AND 0x01 (extract the complemented bit) -> map_bb [1,0] (re-invert) -> additive LFSR scrambler (CCSDS-style mask 0x8A, seed 0x7F, len 7) -> differential encode (mod 2) -> differential decode -> the SAME additive scrambler again (self-inverse in sync = descrambler) -> char/float converter pair -> pack 8 bits -> the original bytes emerge at x16_out. Every stage is a placed Kyttar block; the golden is the IDENTICAL stock-GNU-Radio flowgraph, so the gate proves the whole placed composition is GR-equivalent, and the loopback identity (bytes out == bytes in) is asserted on top. The uchar/float casts at the chip ports are GRC type glue only (spliced on import).'
    generate_options: qt_gui
    id: data_link
    output_language: python
    title: Scrambled data link (unpack -> NOT/AND/map -> LFSR -> diff -> loopback)
  states: {}

blocks:
- name: message
  id: variable
  parameters:
    comment: the transported payload bytes
    value: '"KYTTAR DATA LINK 73"'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: payload length in bytes
    value: len(message)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display rate for the time sink
    value: '8000'
  states: {}
- name: msg_src
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(c) for c in message]'
  states: {}
- name: b2f_in
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: to_raw
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: f2b_in
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: unpack
  id: kyttar_unpack_k_bits
  parameters:
    device_id: '"kyttar_0"'
    k: '8'
  states: {}
- name: inv
  id: kyttar_not
  parameters:
    device_id: '"kyttar_0"'
  states: {}
- name: mask
  id: kyttar_and_const
  parameters:
    constant: '1'
    device_id: '"kyttar_0"'
  states: {}
- name: remap
  id: kyttar_map_bb
  parameters:
    device_id: '"kyttar_0"'
    map: '[1, 0]'
  states: {}
- name: scramble
  id: kyttar_lfsr_scrambler
  parameters:
    bits_per_byte: '1'
    count: '0'
    device_id: '"kyttar_0"'
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: denc
  id: kyttar_diff_encoder
  parameters:
    coding: '"DIFF_DIFFERENTIAL"'
    device_id: '"kyttar_0"'
    modulus: '2'
  states: {}
- name: ddec
  id: kyttar_diff_decoder
  parameters:
    coding: '0'
    device_id: '"kyttar_0"'
    modulus: '2'
  states: {}
- name: descramble
  id: kyttar_lfsr_scrambler
  parameters:
    bits_per_byte: '1'
    count: '0'
    device_id: '"kyttar_0"'
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: c2f
  id: kyttar_char_to_float
  parameters:
    device_id: '"kyttar_0"'
    scale: '128.0'
  states: {}
- name: f2c
  id: kyttar_float_to_char
  parameters:
    device_id: '"kyttar_0"'
    scale: '128.0'
  states: {}
- name: pack
  id: kyttar_pack_k_bits
  parameters:
    device_id: '"kyttar_0"'
    k: '8'
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"tx"'
  states: {}
- name: rx_bytes
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: recovered payload bytes (loopback == the message)
    name: '"recovered bytes"'
    size: burst_len
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: byte value
    ymax: '256'
    ymin: '0'
  states: {}
- name: pack_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_words
  id: blocks_multiply_const_vxx
  parameters:
    comment: kyttar.sink emits the chip stream as q15/32768 floats; restore the raw word value for display
    const: '32768.0'
    type: float
  states: {}

connections:
- [b2f_in, '0', to_raw, '0']
- [c2f, '0', f2c, '0']
- [ddec, '0', descramble, '0']
- [denc, '0', ddec, '0']
- [descramble, '0', c2f, '0']
- [f2b_in, '0', unpack, '0']
- [f2c, '0', pack, '0']
- [inv, '0', mask, '0']
- [mask, '0', remap, '0']
- [msg_src, '0', b2f_in, '0']
- [pack, '0', pack_b2f, '0']
- [remap, '0', scramble, '0']
- [scramble, '0', denc, '0']
- [to_raw, '0', tx_src, '0']
- [tx_sink, '0', rx_words, '0']
- [tx_src, '0', f2b_in, '0']
- [unpack, '0', inv, '0']
- [pack_b2f, '0', tx_sink, '0']
- [rx_words, '0', rx_bytes, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
