options:
  parameters:
    author: Lattrex
    description: 'FEC protocol link on ONE placeKYT array, three streams on the shared duplex ports: ''tx'' = message bytes -> UnpackKBits(8) -> Hamming(7,4) encoder -> 4x3 block interleaver (the interleaved coded bits egress); ''txcrc'' = the same bytes -> on-chip CRC-16/CCITT-FALSE over the 12-byte frame; ''rx'' = the burst-corrupted channel bits -> deinterleaver -> Hamming syndrome decoder -> PackKBits(8) (the recovered bytes egress). The demo story: a 2-bit channel burst that would be UNCORRECTABLE inside one Hamming codeword is dispersed by the interleaver into two codewords (one correctable error each); the CRC Frame Verdict panel shows the chip-computed TX CRC equal to the CRC recomputed over the recovered bytes.'
    generate_options: qt_gui
    id: fec_link
    output_language: python
    title: FEC protocol link (interleaver + Hamming + CRC on one array)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate (scope axis only)
    value: '32000'
  states: {}
- name: tx_len
  id: variable
  parameters:
    comment: TX chip-input bytes (message + flush pads)
    value: stim.n_tx_bytes()
  states: {}
- name: chan_len
  id: variable
  parameters:
    comment: channel bits (alignment prefix + TX bits)
    value: stim.n_channel_bits()
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import fec_demo_stim as stim
  states: {}
- name: msg_src
  id: blocks_vector_source_x
  parameters:
    comment: message + flush pads; finite, no repeat
    repeat: 'False'
    type: byte
    vector: stim.tx_bytes()
  states: {}
- name: msg_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: msg_q15
  id: blocks_multiply_const_vxx
  parameters:
    comment: bytes ride as word/32768 floats (q15 words)
    const: 1.0/32768.0
    type: float
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: tx_len
    comment: 'message bytes -> chip x16_in (stream ''tx''); per-sample paced for import-path robustness: on a wandering auto-P&R corridor the 1:14 rate-EXPANDING coded chain deadlocks saturated (the shipped shortest-path .kyt IS saturated-proven in the gate)'
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: crc_src
  id: kyttar_source
  parameters:
    burst_len: tx_len
    comment: the same message bytes -> chip x16_in (stream 'txcrc')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"txcrc"'
  states: {}
- name: tx_f2b
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: k_unpack
  id: kyttar_unpack_k_bits
  parameters:
    comment: bytes -> bits, MSB first — placed on chip
    device_id: '"kyttar_0"'
    k: '8'
  states: {}
- name: k_henc
  id: kyttar_hamming_encoder
  parameters:
    comment: Hamming(7,4) systematic encoder — placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: henc_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: k_ileave
  id: kyttar_block_interleaver
  parameters:
    comment: 4x3 block interleaver (burst dispersal) — placed on chip
    device_id: '"kyttar_0"'
    rows: '4'
    cols: '3'
    deinterleave: 'False'
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: interleaved coded bits <- chip x16_out (stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"tx"'
  states: {}
- name: tx_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: sink emits word/32768 floats -> x32768
    const: '32768.0'
    type: float
  states: {}
- name: tx_bits_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'the chip TX egress: interleaved Hamming-coded bits'
    name: '"TX interleaved coded bits (chip)"'
    size: stim.n_tx_bits()
    srate: samp_rate
    type: float
    ylabel: bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: crc_f2b
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: k_crc
  id: kyttar_crc16
  parameters:
    comment: frame CRC-16/CCITT-FALSE over the 12 message bytes — placed on chip
    device_id: '"kyttar_0"'
    poly: '0x1021'
    init: '0xFFFF'
    frame_len: '12'
  states: {}
- name: crc_s2f
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: crc_sink
  id: kyttar_sink
  parameters:
    comment: the on-chip TX CRC word <- chip x16_out (stream 'txcrc')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"txcrc"'
  states: {}
- name: chan_src
  id: blocks_vector_source_x
  parameters:
    comment: 'DETERMINISTIC channel: alignment prefix + TX bits XOR the 2-bit burst at +88/89 (stim.error_pattern)'
    repeat: 'False'
    type: byte
    vector: stim.channel_bits()
  states: {}
- name: chan_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: chan_q15
  id: blocks_multiply_const_vxx
  parameters:
    comment: bits ride as word/32768 floats
    const: 1.0/32768.0
    type: float
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: chan_len
    comment: burst-corrupted channel bits -> chip x16_in (stream 'rx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: chan_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'what the channel delivers: the burst sits at +88/89'
    name: '"Channel bits (2-bit burst)"'
    size: chan_len
    srate: samp_rate
    type: float
    ylabel: bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: k_dileave
  id: kyttar_block_interleaver
  parameters:
    comment: 4x3 deinterleaver (disperses the burst) — placed on chip
    device_id: '"kyttar_0"'
    rows: '4'
    cols: '3'
    deinterleave: 'True'
  states: {}
- name: dil_f2b
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: k_hdec
  id: kyttar_hamming_decoder
  parameters:
    comment: Hamming(7,4) syndrome decoder (corrects both dispersed bits) — placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: k_pack
  id: kyttar_pack_k_bits
  parameters:
    comment: bits -> recovered bytes — placed on chip
    device_id: '"kyttar_0"'
    k: '8'
  states: {}
- name: pack_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bytes <- chip x16_out (stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: rx_scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: sink emits word/32768 floats -> x32768
    const: '32768.0'
    type: float
  states: {}
- name: rx_bytes_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 6 alignment zeros, then the recovered message bytes, then pad zeros
    name: '"Recovered bytes (chip)"'
    size: stim.n_rx_bytes()
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: byte value
    ymax: '256'
    ymin: '0'
  states: {}
- name: crc_check
  id: epy_block
  parameters:
    _source_code: |
      """FRAME VERDICT — recompute the CRC of the recovered bytes host-side and
      hold it next to the CHIP-computed TX CRC word. Equality = the frame survived
      the channel burst (dispersed by the interleaver, corrected by the Hamming
      decoder). An embedded block on purpose: this is host-side display glue, and
      stock converter ids are chip-side splice markers to the placeKYT importer.

      in0 = the 'txcrc' kyttar sink output (the chip CRC word as a word/32768
            float); in1 = the 'rx' kyttar sink output (recovered bytes, word/32768
            floats; the message starts after n_skip alignment zero bytes).
      out0 = chip CRC (0..65535), out1 = host-recomputed CRC, out2 = match flag."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self, n_skip=6, frame_len=12):
              gr.basic_block.__init__(self, name='CRC Frame Verdict',
                                      in_sig=[np.float32, np.float32],
                                      out_sig=[np.float32] * 3)
              self.n_skip = int(n_skip)
              self.frame_len = int(frame_len)
              self.chip_crc = None
              self.rx_bytes = []

          def forecast(self, noutput_items, ninputs):
              return [0] * ninputs

          @staticmethod
          def _crc16(data):
              crc = 0xFFFF                       # CRC-16/CCITT-FALSE
              for b in data:
                  crc ^= (int(b) & 0xFF) << 8
                  for _ in range(8):
                      crc = (((crc << 1) ^ 0x1021) if crc & 0x8000
                             else (crc << 1)) & 0xFFFF
              return crc

          def general_work(self, input_items, output_items):
              need = self.n_skip + self.frame_len
              if self.chip_crc is None and len(input_items[0]):
                  w = int(round(float(input_items[0][0]) * 32768.0)) & 0xFFFF
                  self.chip_crc = w
              if len(self.rx_bytes) < need and len(input_items[1]):
                  take = input_items[1][:need - len(self.rx_bytes)]
                  self.rx_bytes += [int(round(float(v) * 32768.0)) & 0xFF
                                    for v in take]
              for i in range(2):
                  if len(input_items[i]):
                      self.consume(i, len(input_items[i]))
              if self.chip_crc is None or len(self.rx_bytes) < need:
                  return 0
              host = self._crc16(self.rx_bytes[self.n_skip:need])
              n = min(len(o) for o in output_items)
              output_items[0][:n] = float(self.chip_crc)
              output_items[1][:n] = float(host)
              output_items[2][:n] = 1.0 if host == self.chip_crc else 0.0
              return n
    comment: chip CRC vs host-recomputed CRC of the recovered bytes
    n_skip: stim.rx_msg_offset()
    frame_len: stim.crc_frame_len()
  states: {}
- name: crc_verdict
  id: qtgui_number_sink
  parameters:
    comment: equal CRCs + flag 1 = the frame is verified
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '65536'
    min: '0'
    name: '"CRC frame verdict"'
    nconnections: '3'
    type: float
    label1: TX CRC (chip)
    label2: RX CRC (recomputed)
    label3: FRAME OK (1 = match)
  states: {}

connections:
- [msg_src, '0', msg_b2f, '0']
- [msg_b2f, '0', msg_q15, '0']
- [msg_q15, '0', tx_src, '0']
- [msg_q15, '0', crc_src, '0']
- [tx_src, '0', tx_f2b, '0']
- [tx_f2b, '0', k_unpack, '0']
- [k_unpack, '0', k_henc, '0']
- [k_henc, '0', henc_b2f, '0']
- [henc_b2f, '0', k_ileave, '0']
- [k_ileave, '0', tx_sink, '0']
- [tx_sink, '0', tx_scale, '0']
- [tx_scale, '0', tx_bits_scope, '0']
- [crc_src, '0', crc_f2b, '0']
- [crc_f2b, '0', k_crc, '0']
- [k_crc, '0', crc_s2f, '0']
- [crc_s2f, '0', crc_sink, '0']
- [chan_src, '0', chan_b2f, '0']
- [chan_b2f, '0', chan_q15, '0']
- [chan_b2f, '0', chan_scope, '0']
- [chan_q15, '0', rx_src, '0']
- [rx_src, '0', k_dileave, '0']
- [k_dileave, '0', dil_f2b, '0']
- [dil_f2b, '0', k_hdec, '0']
- [k_hdec, '0', k_pack, '0']
- [k_pack, '0', pack_b2f, '0']
- [pack_b2f, '0', rx_sink, '0']
- [rx_sink, '0', rx_scale, '0']
- [rx_scale, '0', rx_bytes_scope, '0']
- [crc_sink, '0', crc_check, '0']
- [rx_sink, '0', crc_check, '1']
- [crc_check, '0', crc_verdict, '0']
- [crc_check, '1', crc_verdict, '1']
- [crc_check, '2', crc_verdict, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
