options:
  parameters:
    author: Lattrex
    description: 'FFT128 on the 2P2S board: chain A''s head (chip 0) runs stage 0, its tail (chip 1) runs stages 1..6, joined by the board''s on-carrier series link. Driven through the placeKYT multi-chip GNURadio server.'
    generate_options: qt_gui
    id: fft128_2p2s_demo
    output_language: python
    title: Kyttar FFT128 — a 128-point transform across the 2P2S board's chain A
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    comment: one 128-bin frame past the 127-sample latency
    value: '384'
  states: {}
- name: scope_points
  id: variable
  parameters:
    comment: '< burst_len: a QT time_sink never paints a buffer it cannot fill'
    value: '320'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT's default host port (Run as GNURadio Server binds 58950; change if it prints another)
    value: '58950'
  states: {}
- name: stim
  id: blocks_vector_source_x
  parameters:
    comment: two complex tones (bins 9 and 37 of 128)
    repeat: 'True'
    type: complex
    vector: '[0.45*__import__(''cmath'').exp(2j*3.141592653589793*9*n/128) + 0.35*__import__(''cmath'').exp(2j*3.141592653589793*37*n/128) for n in range(burst_len)]'
  states: {}
- name: kyt_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream 'fft' -> chain A's head, chip 0 x16_in (chip/hop resolved in placeKYT)
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: 'False'
    port_name: '"x16_in"'
    pipelined: 'False'
    repeat: '''yes'''
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"fft"'
  states: {}
- name: die0
  id: kyttar_fft128_die0
  parameters:
    comment: chip 0 (A0, chain A head) — stage 0, the period-64 octant fold. Its output is a PARTIAL transform, not bins.
    device_id: '"kyttar_0"'
  states: {}
- name: die1
  id: kyttar_fft128_die1
  parameters:
    comment: chip 1 (A1, chain A tail) — stages 1..6. Output = the transform's bins, BIT-REVERSED, scale FFT/128.
    device_id: '"kyttar_0"'
  states: {}
- name: kyt_sink
  id: kyttar_sink
  parameters:
    comment: recovered bins off chain A's tail, chip 1 x16_out
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"fft"'
  states: {}
- name: bins
  id: qtgui_time_sink_x
  parameters:
    label1: FFT128 output words (I, Q interleaved)
    autoscale: 'True'
    comment: the transform's bins off chain A's tail. Slot k of each 128-bin frame carries bin bit_reverse_7(k) — the DIF order, no reorder buffer.
    grid: 'True'
    name: '"FFT128 output words (I, Q interleaved)"'
    size: scope_points
    srate: scope_points
    type: float
    ylabel: Magnitude
  states: {}
- name: in_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|input| for comparison'
  states: {}
- name: in_scope
  id: qtgui_time_sink_x
  parameters:
    label1: input |x[n]| (two tones)
    autoscale: 'True'
    comment: the stimulus driving the pair
    grid: 'True'
    name: '"input |x[n]| (two tones)"'
    size: scope_points
    srate: scope_points
    type: float
    ylabel: Magnitude
  states: {}

connections:
- [stim, '0', kyt_src, '0']
- [kyt_src, '0', die0, '0']
- [die0, '0', die1, '0']
- [die1, '0', kyt_sink, '0']
- [kyt_sink, '0', bins, '0']
- [stim, '0', in_mag, '0']
- [in_mag, '0', in_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
