options:
  parameters:
    author: Lattrex
    description: 'FFT128 on the 2P2S board: chain A''s head (chip 0) runs stage 0, its tail (chip 1) runs stages 1..6, joined by the board''s on-carrier series link. Driven through the placeKYT multi-chip GNURadio server. The spectrum plot reads in Hz: bin k of 128 at samp_rate is k*fs/N, so at 32000 Hz each bin is 250 Hz wide and the two demo tones (bins 9 and 37) peak at +2250 Hz and +9250 Hz.'
    generate_options: qt_gui
    id: fft128_2p2s_demo
    output_language: python
    title: Kyttar FFT128 — a 128-point spectrum across the 2P2S board's chain A (250 Hz/bin, tones at +2250 and +9250 Hz)
  states: {}

blocks:
- name: n_fft
  id: variable
  parameters:
    comment: the transform size split across chain A's two dies
    value: '128'
  states: {}
- name: latency
  id: variable
  parameters:
    comment: the chain's pinned pipeline latency (64 from die 0 + 63 from die 1) — the first 127 complex outputs are the zero-initialised startup transient, not a frame
    value: '127'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: two whole 128-bin frames past the 127-sample latency
    value: '384'
  states: {}
- name: scope_points
  id: variable
  parameters:
    comment: '< burst_len: a QT time_sink never paints a buffer it cannot fill'
    value: '320'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: the rate the I/Q stimulus is DECLARED to be sampled at. The array is asynchronous — it has no clock of its own, so it transforms whatever stream you hand it and the sample rate is entirely YOURS to state. It is what turns a bin index into a physical frequency, so the spectrum axis can read in Hz.
    value: '32000'
  states: {}
- name: bin_hz
  id: variable
  parameters:
    comment: BIN WIDTH = samp_rate / n_fft = 32000/128 = 250 Hz. Bin k of N at rate fs is centred on k*fs/N, and bins at or above N/2 are NEGATIVE frequencies (k-N)*fs/N. The demo tones at bins 9 and 37 are therefore 2250 Hz and 9250 Hz.
    value: samp_rate / n_fft
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT's default host port (Run as GNURadio Server binds 58950; change if it prints another)
    value: '58950'
  states: {}
- name: tone_a
  id: variable
  parameters:
    comment: 'the FIRST demo tone''s natural FFT bin. ON-BIN (an integer number of cycles per 128-sample frame) so the answer is a clean line with no leakage. The chip emits it at SLOT bit_reverse_7(9) = 72; the spectrum block puts it back at 9. In Hz: 9 * bin_hz = 2250 Hz.'
    value: '9'
  states: {}
- name: tone_b
  id: variable
  parameters:
    comment: the SECOND demo tone's natural FFT bin. SLOT bit_reverse_7(37) = 82 off the chip; 37 * bin_hz = 9250 Hz on the plot.
    value: '37'
  states: {}
- name: stim
  id: blocks_vector_source_x
  parameters:
    comment: two complex tones — bins 9 and 37 of 128, i.e. 2250 Hz and 9250 Hz at samp_rate = 32000
    repeat: 'True'
    type: complex
    vector: '[0.45*__import__(''cmath'').exp(2j*3.141592653589793*tone_a*n/n_fft) + 0.35*__import__(''cmath'').exp(2j*3.141592653589793*tone_b*n/n_fft) for n in range(burst_len)]'
  states: {}
- name: kyt_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream 'fft' -> chain A's head, chip 0 x16_in (chip/hop resolved in placeKYT)
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"q15"'
    port_name: '"x16_in"'
    pipelined: 'False'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"fft"'
  states: {}
- name: die0
  id: kyttar_fft128_die0
  parameters:
    comment: chip 0 (A0, chain A head) — stage 0, the period-64 octant fold. Its output is a PARTIAL transform, not bins.
    device_id: '"kyttar_0"'
  states: {}
- name: die1
  id: kyttar_fft128_die1
  parameters:
    comment: chip 1 (A1, chain A tail) — stages 1..6. Output = the transform's bins, BIT-REVERSED, scale FFT/128.
    device_id: '"kyttar_0"'
  states: {}
- name: kyt_sink
  id: kyttar_sink
  parameters:
    comment: recovered bins off chain A's tail, chip 1 x16_out
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"fft"'
  states: {}
- name: spectrum
  id: epy_block
  parameters:
    _source_code: |
      """The chain tail's INTERLEAVED I/Q words -> a centred POWER SPECTRUM.

      This is the example's display contract, and it exists because the raw
      sink stream is NOT a spectrum. Four things separate them, and every one
      of them is load-bearing:

      1. DE-INTERLEAVE. Chain A's tail is a COMPLEX exit cell: it emits
         out_i then out_q from one cell, so the sink's float stream is
         I, Q, I, Q ... at the q15/32768 scale — two words per frequency
         bin. Plotting that stream directly is what the "spikes flow across
         the screen with time on the x axis" report was looking at: a time
         series of raw words, where a single bin's energy shows up as two
         adjacent samples and the bin INDEX is nowhere on the axis.

      2. STRIP THE LATENCY. The transform's pipeline latency is 127 samples
         (64 from die 0, 63 from die 1), so the first 127 complex outputs of
         a burst are the deterministic startup values of the zero-initialised
         pipeline, not a frame. Burst boundaries are found by counting
         complex samples modulo burst_len.

      3. UN-REVERSE. The placed FFT emits DIF order with deliberately NO
         reorder buffer: output slot k of each 128-sample frame carries
         frequency bin bit_reverse_7(k). Slot 72 is bin 9; slot 82 is bin
         37; slot 1 is bin 64. A plot fed the raw slots is a SCRAMBLED
         spectrum that still looks plausible, which is exactly why this
         block exists and why the gate pins the mapping.

      4. FFTSHIFT, so the x axis can read in Hz and be MONOTONIC. Natural
         bin k of an N-point transform at sample rate fs is the frequency

             f(k) = k*fs/N          for k <  N/2   (positive frequencies)
             f(k) = (k-N)*fs/N      for k >= N/2   (negative frequencies)

         i.e. the natural-order vector runs 0 -> +fs/2 and then jumps to
         -fs/2 -> 0, which no single linear axis can label. Rolling the
         vector by N/2 puts bin N/2 first, so the emitted vector runs
         monotonically from -fs/2 in steps of fs/N and the sink's
         set_x_axis(-samp_rate/2, bin_hz) labels every point correctly.
         At fs = 32000 and N = 128 the step is 250 Hz, and the demo's two
         tones (natural bins 9 and 37) land at indices 9 + 64 = 73 ->
         -16000 + 73*250 = +2250 Hz = 9*250, and 37 + 64 = 101 ->
         -16000 + 101*250 = +9250 Hz = 37*250.

      Emits one 128-bin POWER vector per whole frame, in ascending frequency
      order from -fs/2. Power is |z|^2 at the FFT/128 scale, so a full-scale
      coherent bin reads 1.0.
      """
      import numpy as np
      from gnuradio import gr


      def _bitrev(n):
          bits = int(n).bit_length() - 1
          out = []
          for k in range(n):
              r, v = 0, k
              for _ in range(bits):
                  r = (r << 1) | (v & 1)
                  v >>= 1
              out.append(r)
          return np.array(out, dtype=np.intp)


      class blk(gr.basic_block):
          def __init__(self, n_fft=128, latency=127, burst_len=384):
              gr.basic_block.__init__(
                  self, name='FFT128 words to centred spectrum',
                  in_sig=[np.float32], out_sig=[(np.float32, int(n_fft))])
              self.n = int(n_fft)
              self.latency = int(latency)
              self.burst = int(burst_len)
              # slot -> natural bin. The map is an involution, so this same
              # permutation both scrambles and unscrambles; applying it to the
              # emitted slots yields natural bin order.
              self.rev = _bitrev(self.n)
              # natural bin -> position on the CENTRED (-fs/2 .. +fs/2) axis.
              # This is exactly np.fft.fftshift's permutation, written out so
              # the mapping is readable in the flowgraph.
              self.shift = (np.arange(self.n) + self.n // 2) % self.n
              self.buf = np.zeros(0, dtype=np.float32)
              self.pos = 0          # index of buf[0] in COMPLEX samples of the burst

          def forecast(self, noutput_items, ninputs):
              # two float words per complex bin
              return [2 * (noutput_items * self.n + self.n)] * ninputs

          def general_work(self, input_items, output_items):
              x = input_items[0]
              self.buf = np.concatenate([self.buf, np.asarray(x, np.float32)])
              self.consume(0, len(x))
              out = output_items[0]
              made = 0
              while made < len(out):
                  # position of buf[0] inside its burst, in COMPLEX samples
                  off = self.pos % self.burst
                  if off < self.latency:            # inside the startup transient
                      drop = min(self.latency - off, len(self.buf) // 2)
                      if drop == 0:
                          break
                      self.buf = self.buf[2 * drop:]
                      self.pos += drop
                      continue
                  if off + self.n > self.burst:
                      # THE BURST'S RAGGED TAIL. burst_len is not latency + k*n_fft
                      # (384 vs 127 + 2*128 = 383), so a burst ends with fewer than
                      # n_fft samples left over. Those are not a frame, and a frame
                      # STRADDLING the boundary is 1 real sample plus 127 of the
                      # NEXT burst's zero-fill transient — measured as an all-zero
                      # "spectrum" painted as every third frame. Drop the remainder.
                      drop = min(self.burst - off, len(self.buf) // 2)
                      if drop == 0:
                          break
                      self.buf = self.buf[2 * drop:]
                      self.pos += drop
                      continue
                  if len(self.buf) < 2 * self.n:
                      break
                  frame = self.buf[:2 * self.n]
                  self.buf = self.buf[2 * self.n:]
                  self.pos += self.n
                  # DE-INTERLEAVE: out_i, out_q per bin -> one complex slot
                  bins = frame[0::2].astype(np.float64) \
                      + 1j * frame[1::2].astype(np.float64)
                  power = np.abs(bins) ** 2
                  nat = np.zeros(self.n, dtype=np.float32)
                  nat[self.rev] = power          # slots -> natural bin order
                  centred = np.zeros(self.n, dtype=np.float32)
                  centred[self.shift] = nat      # natural bins -> -fs/2 .. +fs/2
                  out[made][:] = centred
                  made += 1
              return made
    burst_len: burst_len
    comment: interleaved I/Q chip words -> a 128-bin POWER vector in ASCENDING FREQUENCY order from -samp_rate/2 (de-interleave, un-reverse, fftshift), with the 127-sample startup transient stripped
    latency: latency
    n_fft: n_fft
  states: {}
- name: to_db
  id: epy_block
  parameters:
    _source_code: |
      """Per-bin power -> dBFS, for a log spectrum display.

      The spectrum block upstream computes |z|^2 from the chain tail's
      interleaved I/Q at the q15/32768 scale, so this is just 10*log10 with a
      floor. The transform's FFT/128 scale puts a full-scale coherent bin at
      power 1.0 = 0 dBFS, so the plot reads directly in dBFS.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, n_fft=128, floor_db=-90.0):
              gr.sync_block.__init__(
                  self, name='Power to dBFS',
                  in_sig=[(np.float32, int(n_fft))],
                  out_sig=[(np.float32, int(n_fft))])
              self.floor = float(floor_db)
              self.eps = 10.0 ** (self.floor / 10.0)

          def work(self, input_items, output_items):
              x = np.maximum(np.asarray(input_items[0]), self.eps)
              output_items[0][:] = (10.0 * np.log10(x)).astype(np.float32)
              return len(output_items[0])
    comment: linear power -> dBFS (0 dBFS = a full-scale coherent bin)
    floor_db: '-90.0'
    n_fft: n_fft
  states: {}
- name: spectrum_sink
  id: qtgui_vector_sink_f
  parameters:
    label1: on-chip FFT128 power spectrum (bin k = k*samp_rate/128 Hz)
    width1: '3'
    comment: THE SPECTRUM — 128 bins off chain A's tail, on a real FREQUENCY axis. x runs from -samp_rate/2 = -16000 Hz in steps of bin_hz = samp_rate/n_fft = 250 Hz, so point i is (i - 64)*250 Hz. The demo tones (natural bins 9 and 37) are the lines at +2250 Hz and +9250 Hz; every other bin sits on the -90 dBFS floor.
    grid: 'True'
    name: '"On-chip FFT128 spectrum — 250 Hz/bin, tones at +2250 Hz and +9250 Hz (dBFS)"'
    vlen: n_fft
    x_axis_label: '"frequency (Hz) — bin k of 128 at samp_rate = k*samp_rate/128"'
    x_start: '-samp_rate / 2'
    x_step: bin_hz
    x_units: '"Hz"'
    y_axis_label: '"power (dBFS)"'
    ymax: '5'
    ymin: '-95'
  states: {}
- name: in_mag
  id: blocks_complex_to_mag
  parameters:
    comment: '|input| for comparison'
  states: {}
- name: in_scope
  id: qtgui_time_sink_x
  parameters:
    label1: input |x[n]| (two tones)
    autoscale: 'True'
    comment: the stimulus driving the pair
    grid: 'True'
    name: '"input |x[n]| (two tones)"'
    size: scope_points
    srate: scope_points
    type: float
    ylabel: Magnitude
  states: {}

connections:
- [stim, '0', kyt_src, '0']
- [kyt_src, '0', die0, '0']
- [die0, '0', die1, '0']
- [die1, '0', kyt_sink, '0']
- [kyt_sink, '0', spectrum, '0']
- [spectrum, '0', to_db, '0']
- [to_db, '0', spectrum_sink, '0']
- [stim, '0', in_mag, '0']
- [in_mag, '0', in_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
