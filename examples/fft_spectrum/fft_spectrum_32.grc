options:
  parameters:
    author: Lattrex
    description: LIVE SPECTRUM ANALYZER on the Kyttar array (the SMALLER variant, N=32). A complex I/Q burst drives the placed 32-point streaming R2SDF FFT (FFT32, 60 cells) whose complex output feeds a placed Complex-to-Mag^2 stage, so the transform AND the per-bin power both run ON CHIP. The chip emits bins in BIT-REVERSED (DIF) order; the 'unreverse' block undoes that map and emits a natural-order 32-bin vector, so the demo tone at bin 11 (which leaves the chip at slot 26) appears exactly at 11 on the plot. Open fft_spectrum_32.kyt in placeKYT -> Run as GNURadio Server (port 58950), then Execute here.
    generate_options: qt_gui
    id: fft_spectrum_32
    output_language: python
    title: Kyttar FFT32 spectrum analyzer — the smaller streaming FFT
  states: {}

blocks:
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: n_fft
  id: variable
  parameters:
    comment: transform size of the placed FFT32 block
    value: '32'
  states: {}
- name: latency
  id: variable
  parameters:
    comment: the block's pinned pipeline latency (N-1) — the first 31 outputs are the zero-initialized startup transient, not a frame
    value: '31'
  states: {}
- name: frames
  id: variable
  parameters:
    comment: whole 64-bin frames per dispatched burst
    value: '3'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: complex samples per burst = latency + n_fft*frames = 127
    value: latency + n_fft * frames
  states: {}
- name: tone_bin
  id: variable
  parameters:
    comment: which FFT bin the demo tone sits in. ON-BIN (an integer number of cycles per 64-sample frame) so the answer is a single clean line with no leakage. The chip emits it at SLOT bit_reverse_5(11) = 26; the unreverse block puts it back at 11.
    value: '11'
  states: {}
- name: amplitude
  id: variable
  parameters:
    comment: 0.9, NOT full scale. The hosted server converts an injected float with min(0.999, f) before quantizing, so a 0.99997 sample is clipped to word 32735 instead of 32767 (8 samples of a 255-sample full-scale burst). At 0.9 the server's conversion and the demo module's agree on EVERY sample, so the live path is bit-exact to the reference.
    value: '0.9'
  states: {}
- name: iq_stim
  id: variable
  parameters:
    comment: ON-BIN complex exponential at bin 11 — an exact integer number of cycles per 64-sample frame, so the answer is a single clean spectral line with no leakage
    value: list(amplitude*np.exp(2j*np.pi*tone_bin*np.arange(burst_len)/n_fft))
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: the demo I/Q burst — exactly burst_len samples, repeating so the source always has its whole burst available; the kyttar source dispatches ONE burst (from index 0) and the sink loops that genuine result
    repeat: 'True'
    type: complex
    vector: iq_stim
  states: {}
- name: ksrc
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: 'I/Q burst -> chip x16_in. ONE burst per Run (repeat = no) so the burst starts at vector index 0 and the 63-sample latency lines the frames up exactly. A REPEAT-burst source re-arms mid-vector — the next burst then starts at an arbitrary ROTATION, which slides the frame grid and puts the tone on the wrong slot (measured at N=64: a 55-sample rotation moved the peak from slot 52 to 43). The display keeps refreshing via the sink''s server_repeat.'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"spectrum"'
  states: {}
- name: fft
  id: kyttar_fft32
  parameters:
    comment: 32-point streaming R2SDF FFT — 60 cells, five stages, placed on chip. Output is BIT-REVERSED, scale FFT/32, latency 31.
    device_id: '"kyttar_0"'
  states: {}
- name: mag2
  id: kyttar_complex_to_mag_squared
  parameters:
    comment: per-bin POWER, computed on chip (one cell) — what leaves x16_out is already a real power word per bin
    device_id: '"kyttar_0"'
  states: {}
- name: ksink
  id: kyttar_sink
  parameters:
    comment: per-bin power <- x16_out (q15 floats). server_repeat LOOPS the genuine one-batch result so the vector display keeps painting without a re-armed source rotating the burst (see the source's comment); every repetition is a byte-identical replay of the SAME real chip output, and the gate asserts that repetition integrity rather than taking it on trust.
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"spectrum"'
  states: {}
- name: unreverse
  id: epy_block
  parameters:
    _source_code: |
      """UN-REVERSE the chip's bin order — the example's display contract.

      The placed FFT emits DIF order with deliberately NO reorder buffer:
      output slot k of each 32-sample frame carries frequency bin
      bit_reverse_5(k). Slot 26 is bin 11; slot 1 is bin 16. A plot fed the
      raw slots is a SCRAMBLED spectrum that still looks plausible, which is
      exactly why this block exists and why the gate pins the mapping.

      It also strips the block's 31-sample pipeline LATENCY: the first 31
      outputs of a burst are the deterministic startup values of the
      zero-initialized pipeline, not a frame. Burst boundaries are found by
      counting samples modulo burst_len, which is what the repeat-burst
      source delivers.

      Emits one natural-order 32-bin power VECTOR per whole frame.
      """
      import numpy as np
      from gnuradio import gr


      def _bitrev(n):
          bits = int(n).bit_length() - 1
          out = []
          for k in range(n):
              r, v = 0, k
              for _ in range(bits):
                  r = (r << 1) | (v & 1)
                  v >>= 1
              out.append(r)
          return np.array(out, dtype=np.intp)


      class blk(gr.basic_block):
          def __init__(self, n_fft=32, latency=31, burst_len=127):
              gr.basic_block.__init__(
                  self, name='FFT bin un-reverse',
                  in_sig=[np.float32], out_sig=[(np.float32, int(n_fft))])
              self.n = int(n_fft)
              self.latency = int(latency)
              self.burst = int(burst_len)
              # slot -> natural bin. The map is an involution, so this same
              # permutation both scrambles and unscrambles; applying it to the
              # emitted slots yields natural bin order.
              self.rev = _bitrev(self.n)
              self.buf = np.zeros(0, dtype=np.float32)
              self.pos = 0          # index of buf[0] within the current burst

          def forecast(self, noutput_items, ninputs):
              return [noutput_items * self.n + self.n] * ninputs

          def general_work(self, input_items, output_items):
              x = input_items[0]
              self.buf = np.concatenate([self.buf, np.asarray(x, np.float32)])
              self.consume(0, len(x))
              out = output_items[0]
              made = 0
              while made < len(out):
                  # position of buf[0] inside its burst
                  off = self.pos % self.burst
                  if off < self.latency:            # inside the startup transient
                      drop = min(self.latency - off, len(self.buf))
                      if drop == 0:
                          break
                      self.buf = self.buf[drop:]
                      self.pos += drop
                      continue
                  if len(self.buf) < self.n:
                      break
                  frame = self.buf[:self.n]
                  self.buf = self.buf[self.n:]
                  self.pos += self.n
                  nat = np.zeros(self.n, dtype=np.float32)
                  nat[self.rev] = frame
                  out[made][:] = nat
                  made += 1
              return made
    burst_len: burst_len
    comment: bit-reversed chip slots -> natural-order 64-bin power vector (and strips the 63-sample startup transient)
    latency: latency
    n_fft: n_fft
  states: {}
- name: to_db
  id: epy_block
  parameters:
    _source_code: |
      """Per-bin power -> dBFS, for a log spectrum display.

      The chip already emits POWER (re^2+im^2 in Q15), so this is just
      10*log10 with a floor. The FFT/32 scale puts a full-scale coherent
      bin at power 1.0 = 0 dBFS, so the plot reads directly in dBFS.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, n_fft=32, floor_db=-90.0):
              gr.sync_block.__init__(
                  self, name='Power to dBFS',
                  in_sig=[(np.float32, int(n_fft))],
                  out_sig=[(np.float32, int(n_fft))])
              self.floor = float(floor_db)
              self.eps = 10.0 ** (self.floor / 10.0)

          def work(self, input_items, output_items):
              x = np.maximum(np.asarray(input_items[0]), self.eps)
              output_items[0][:] = (10.0 * np.log10(x)).astype(np.float32)
              return len(output_items[0])
    comment: linear power -> dBFS (0 dBFS = a full-scale coherent bin)
    floor_db: '-90.0'
    n_fft: n_fft
  states: {}
- name: spectrum_sink
  id: qtgui_vector_sink_f
  parameters:
    comment: THE SPECTRUM — 32 natural-order bins straight off the chip. The demo tone sits at bin 11 at 0 dBFS.
    grid: 'True'
    label1: on-chip FFT32 power spectrum
    name: '"On-chip FFT32 spectrum (natural bin order, dBFS)"'
    vlen: n_fft
    width1: '3'
    x_axis_label: '"FFT bin (natural order)"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"power (dBFS)"'
    ymax: '5'
    ymin: '-95'
  states: {}

connections:
- [src, '0', ksrc, '0']
- [ksrc, '0', fft, '0']
- [fft, '0', mag2, '0']
- [mag2, '0', ksink, '0']
- [ksink, '0', unreverse, '0']
- [unreverse, '0', to_db, '0']
- [to_db, '0', spectrum_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
