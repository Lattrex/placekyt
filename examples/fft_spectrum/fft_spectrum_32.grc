options:
  parameters:
    author: Lattrex
    description: LIVE SPECTRUM ANALYZER on the Kyttar array (the SMALLER variant, N=32). A complex I/Q burst drives the placed 32-point streaming R2SDF FFT (FFT32, 60 cells) whose complex output feeds a placed Complex-to-Mag^2 stage, so the transform AND the per-bin power both run ON CHIP. The chip emits bins in BIT-REVERSED (DIF) order; the 'unreverse' block undoes that map and then fftshifts, emitting a 32-bin vector in ascending FREQUENCY order from -samp_rate/2. Bin k of N at rate fs is k*fs/N Hz (bins >= N/2 are the negative frequencies (k-N)*fs/N), so at the default samp_rate = 32000 each bin is 1000 Hz wide and the demo tone at bin 11 (which leaves the chip at slot 26) appears at +11000 Hz on the plot. A second scope shows the stimulus itself, so you can see the sinusoid the spike comes from. Open fft_spectrum_32.kyt in placeKYT -> Run as GNURadio Server (port 58950), then Execute here.
    generate_options: qt_gui
    id: fft_spectrum_32
    output_language: python
    title: Kyttar FFT32 spectrum analyzer — the smaller streaming FFT
  states: {}

blocks:
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: n_fft
  id: variable
  parameters:
    comment: transform size of the placed FFT32 block
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: the rate the I/Q stimulus is DECLARED to be sampled at. The array is asynchronous — it has no clock of its own, so it transforms whatever stream you hand it and the sample rate is entirely YOURS to state. It is what turns a bin index into a physical frequency, so the spectrum axis can read in Hz. Change it and the whole axis rescales; the chip does not change at all.
    value: '32000'
  states: {}
- name: bin_hz
  id: variable
  parameters:
    comment: BIN WIDTH = samp_rate / n_fft = 32000/32 = 1000 Hz. Bin k of N at rate fs is centred on k*fs/N, and bins at or above N/2 are NEGATIVE frequencies (k-N)*fs/N. The demo tone at bin 11 is therefore 11*1000 = 11000 Hz — the SAME bin index as the 64-point variant but TWICE the frequency, because a half-length transform has twice the bin width.
    value: samp_rate / n_fft
  states: {}
- name: latency
  id: variable
  parameters:
    comment: the block's pinned pipeline latency (N-1) — the first 31 outputs are the zero-initialized startup transient, not a frame
    value: '31'
  states: {}
- name: frames
  id: variable
  parameters:
    comment: whole 64-bin frames per dispatched burst
    value: '3'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: complex samples per burst = latency + n_fft*frames = 127
    value: latency + n_fft * frames
  states: {}
- name: tone_bin
  id: variable
  parameters:
    comment: which FFT bin the demo tone sits in. ON-BIN (an integer number of cycles per 32-sample frame) so the answer is a single clean line with no leakage. The chip emits it at SLOT bit_reverse_5(11) = 26; the unreverse block puts it back at 11. In Hz that is bin 11 * bin_hz = 11 * 1000 = 11000 Hz, which is where the plot's marker lands.
    value: '11'
  states: {}
- name: amplitude
  id: variable
  parameters:
    comment: 0.9, NOT full scale. The hosted server converts an injected float with min(0.999, f) before quantizing, so a 0.99997 sample is clipped to word 32735 instead of 32767 (8 samples of a 255-sample full-scale burst). At 0.9 the server's conversion and the demo module's agree on EVERY sample, so the live path is bit-exact to the reference.
    value: '0.9'
  states: {}
- name: iq_stim
  id: variable
  parameters:
    comment: ON-BIN complex exponential at bin 11 — an exact integer number of cycles per 64-sample frame, so the answer is a single clean spectral line with no leakage
    value: list(amplitude*np.exp(2j*np.pi*tone_bin*np.arange(burst_len)/n_fft))
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: the demo I/Q burst — exactly burst_len samples, repeating so the source always has its whole burst available; the kyttar source dispatches ONE burst (from index 0) and the sink loops that genuine result
    repeat: 'True'
    type: complex
    vector: iq_stim
  states: {}
- name: ksrc
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: 'I/Q burst -> chip x16_in. ONE burst per Run (repeat = no) so the burst starts at vector index 0 and the 31-sample latency lines the frames up exactly. A REPEAT-burst source re-arms mid-vector — the next burst then starts at an arbitrary ROTATION, which slides the frame grid and puts the tone on the wrong slot (measured at N=64: a 55-sample rotation moved the peak from slot 52 to 43). The display keeps refreshing via the sink''s server_repeat.'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"spectrum"'
  states: {}
- name: fft
  id: kyttar_fft32
  parameters:
    comment: 32-point streaming R2SDF FFT — 60 cells, five stages, placed on chip. Output is BIT-REVERSED, scale FFT/32, latency 31.
    device_id: '"kyttar_0"'
  states: {}
- name: mag2
  id: kyttar_complex_to_mag_squared
  parameters:
    comment: per-bin POWER, computed on chip (one cell) — what leaves x16_out is already a real power word per bin
    device_id: '"kyttar_0"'
  states: {}
- name: ksink
  id: kyttar_sink
  parameters:
    comment: per-bin power <- x16_out (q15 floats). server_repeat LOOPS the genuine one-batch result so the vector display keeps painting without a re-armed source rotating the burst (see the source's comment); every repetition is a byte-identical replay of the SAME real chip output, and the gate asserts that repetition integrity rather than taking it on trust.
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"spectrum"'
  states: {}
- name: unreverse
  id: epy_block
  parameters:
    _source_code: |
      """UN-REVERSE the chip's bin order and CENTRE it on 0 Hz — the
      example's display contract.

      Two maps, applied in this order.

      1. UN-REVERSE. The placed FFT emits DIF order with deliberately NO
         reorder buffer: output slot k of each 32-sample frame carries
         frequency bin bit_reverse_5(k). Slot 26 is bin 11; slot 1 is bin
         16. A plot fed the raw slots is a SCRAMBLED spectrum that still
         looks plausible, which is exactly why this block exists and why
         the gate pins the mapping.

      2. FFTSHIFT, so the x axis can read in Hz and be MONOTONIC. Natural
         bin k of an N-point transform at sample rate fs is the frequency

             f(k) = k*fs/N          for k <  N/2   (positive frequencies)
             f(k) = (k-N)*fs/N      for k >= N/2   (negative frequencies)

         i.e. the natural-order vector runs 0 -> +fs/2 and then jumps to
         -fs/2 -> 0, which no single linear axis can label. Rolling the
         vector by N/2 puts bin N/2 first, so the emitted vector runs
         monotonically from -fs/2 in steps of fs/N and the sink's
         set_x_axis(-samp_rate/2, bin_hz) labels every point correctly.
         At fs = 32000 and N = 32 the step is 1000 Hz and the demo tone,
         natural bin 11, lands at index 11 + 16 = 27 -> -16000 + 27*1000 =
         +11000 Hz = 11*1000. That IS the mapping the README states.

      It also strips the block's 31-sample pipeline LATENCY: the first 31
      outputs of a burst are the deterministic startup values of the
      zero-initialized pipeline, not a frame. Burst boundaries are found by
      counting samples modulo burst_len, which is what the repeat-burst
      source delivers.

      Emits one 32-bin power VECTOR per whole frame, in ascending frequency
      order from -fs/2.
      """
      import numpy as np
      from gnuradio import gr


      def _bitrev(n):
          bits = int(n).bit_length() - 1
          out = []
          for k in range(n):
              r, v = 0, k
              for _ in range(bits):
                  r = (r << 1) | (v & 1)
                  v >>= 1
              out.append(r)
          return np.array(out, dtype=np.intp)


      class blk(gr.basic_block):
          def __init__(self, n_fft=32, latency=31, burst_len=127):
              gr.basic_block.__init__(
                  self, name='FFT bins to centred spectrum',
                  in_sig=[np.float32], out_sig=[(np.float32, int(n_fft))])
              self.n = int(n_fft)
              self.latency = int(latency)
              self.burst = int(burst_len)
              # slot -> natural bin. The map is an involution, so this same
              # permutation both scrambles and unscrambles; applying it to the
              # emitted slots yields natural bin order.
              self.rev = _bitrev(self.n)
              # natural bin -> position on the CENTRED (-fs/2 .. +fs/2) axis.
              # This is exactly np.fft.fftshift's permutation, written out so
              # the mapping is readable in the flowgraph.
              self.shift = (np.arange(self.n) + self.n // 2) % self.n
              self.buf = np.zeros(0, dtype=np.float32)
              self.pos = 0          # index of buf[0] within the current burst

          def forecast(self, noutput_items, ninputs):
              return [noutput_items * self.n + self.n] * ninputs

          def general_work(self, input_items, output_items):
              x = input_items[0]
              self.buf = np.concatenate([self.buf, np.asarray(x, np.float32)])
              self.consume(0, len(x))
              out = output_items[0]
              made = 0
              while made < len(out):
                  # position of buf[0] inside its burst
                  off = self.pos % self.burst
                  if off < self.latency:            # inside the startup transient
                      drop = min(self.latency - off, len(self.buf))
                      if drop == 0:
                          break
                      self.buf = self.buf[drop:]
                      self.pos += drop
                      continue
                  if len(self.buf) < self.n:
                      break
                  frame = self.buf[:self.n]
                  self.buf = self.buf[self.n:]
                  self.pos += self.n
                  nat = np.zeros(self.n, dtype=np.float32)
                  nat[self.rev] = frame          # slots -> natural bin order
                  centred = np.zeros(self.n, dtype=np.float32)
                  centred[self.shift] = nat      # natural bins -> -fs/2 .. +fs/2
                  out[made][:] = centred
                  made += 1
              return made
    burst_len: burst_len
    comment: bit-reversed chip slots -> 32-bin power vector in ASCENDING FREQUENCY order from -samp_rate/2 (un-reverse, then fftshift), and strips the 31-sample startup transient
    latency: latency
    n_fft: n_fft
  states: {}
- name: to_db
  id: epy_block
  parameters:
    _source_code: |
      """Per-bin power -> dBFS, for a log spectrum display.

      The chip already emits POWER (re^2+im^2 in Q15), so this is just
      10*log10 with a floor. The FFT/32 scale puts a full-scale coherent
      bin at power 1.0 = 0 dBFS, so the plot reads directly in dBFS.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, n_fft=32, floor_db=-90.0):
              gr.sync_block.__init__(
                  self, name='Power to dBFS',
                  in_sig=[(np.float32, int(n_fft))],
                  out_sig=[(np.float32, int(n_fft))])
              self.floor = float(floor_db)
              self.eps = 10.0 ** (self.floor / 10.0)

          def work(self, input_items, output_items):
              x = np.maximum(np.asarray(input_items[0]), self.eps)
              output_items[0][:] = (10.0 * np.log10(x)).astype(np.float32)
              return len(output_items[0])
    comment: linear power -> dBFS (0 dBFS = a full-scale coherent bin)
    floor_db: '-90.0'
    n_fft: n_fft
  states: {}
- name: spectrum_sink
  id: qtgui_vector_sink_f
  parameters:
    comment: THE SPECTRUM — 32 bins straight off the chip, on a real FREQUENCY axis. x runs from -samp_rate/2 = -16000 Hz in steps of bin_hz = samp_rate/n_fft = 1000 Hz, so point i is (i - 16)*1000 Hz. The demo tone (natural bin 11) is the line at +11000 Hz, at about -0.9 dBFS; every other bin sits on the -90 dBFS floor. Same bin index as the 64-point variant, but TWICE the frequency — a half-length transform has twice the bin width.
    grid: 'True'
    label1: on-chip FFT32 power spectrum (bin k = k*samp_rate/32 Hz)
    name: '"On-chip FFT32 spectrum — 1000 Hz/bin, tone at +11000 Hz (dBFS)"'
    vlen: n_fft
    width1: '3'
    x_axis_label: '"frequency (Hz) — bin k of 32 at samp_rate = k*samp_rate/32"'
    x_start: '-samp_rate / 2'
    x_step: bin_hz
    x_units: '"Hz"'
    y_axis_label: '"power (dBFS)"'
    ymax: '5'
    ymin: '-95'
  states: {}
- name: stim_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'WHAT THE CHIP IS ACTUALLY BEING FED — the I and Q rails of the stimulus, on a time axis. This answers ''the waveform isn''t a sinusoid, so what is it capturing the spike on?''. It IS the sinusoid: an 11000 Hz complex tone, I = cos and Q = sin, one Q15 word per sample. In placeKYT''s own waveform pane the same stream appears as fft32.xi / fft32.xq and looks like a STAIRCASE — correctly, because bin 11 of 32 is only 32/11 = 2.9 samples per cycle and a per-word trace draws each sample as a step. This scope plots 4 frames (128 samples = 44 cycles). At N=32 bin 11 is close to Nyquist, so even here the trace is coarse; set tone_bin = 1 for one full cycle per 32-sample frame, the slowest and smoothest stimulus this example can show.'
    grid: 'True'
    label1: I (xi rail)
    label2: Q (xq rail)
    name: '"Stimulus into x16_in — I/Q of the 11000 Hz tone"'
    size: 4 * n_fft
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ylabel: amplitude
    ymax: '1.1'
    ymin: '-1.1'
  states: {}

connections:
- [src, '0', ksrc, '0']
- [src, '0', stim_scope, '0']
- [ksrc, '0', fft, '0']
- [fft, '0', mag2, '0']
- [mag2, '0', ksink, '0']
- [ksink, '0', unreverse, '0']
- [unreverse, '0', to_db, '0']
- [to_db, '0', spectrum_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
