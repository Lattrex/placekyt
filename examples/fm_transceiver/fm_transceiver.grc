options:
  parameters:
    author: Kyttar
    description: FM TRANSCEIVER from REAL Kyttar blocks. SEPARATE TX chain (audio -> frequency_modulator -> FM passband, stream 'tx') and SEPARATE RX chain (complex FM I/Q -> quadrature_demod -> recovered audio, stream 'rx') sharing ONE chip by stream_id, like the AM transceiver. Verified |corr| ~ 1.0. Imports + auto-P&R-routes into placeKYT.
    generate_options: qt_gui
    id: fm_transceiver
    output_language: python
    title: FM transceiver (on-chip, real blocks) — TX modulate + RX demodulate
  states: {}

blocks:
- name: f_dev
  id: variable
  parameters:
    comment: FM peak deviation (Hz)
    value: '1500.0'
  states: {}
- name: n_samp
  id: variable
  parameters:
    comment: audio burst length
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000.0'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT GNURadio-server port
    value: '58950'
  states: {}
- name: fm_rf
  id: blocks_vector_source_x
  parameters:
    comment: 'RX input: the complex FM passband (same audio+sensitivity); I/Q, no repeat'
    repeat: 'False'
    type: complex
    vector: stim.fm_iq(n_samp)
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import fm_demo_stim as stim
  states: {}
- name: rx_audio
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: recovered audio (RX)
    name: recovered audio (RX)
    size: stim.points(n_samp)
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: rx_demod
  id: kyttar_quadrature_demod
  parameters:
    comment: 'FM demod (gain = fs/(2*pi*f_dev) = 1/sensitivity): y = gain*arg(x[n]*conj(x[n-1]))'
    device_id: '"kyttar_0"'
    gain: '3.3953054526271007'
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered audio <- chip x16_out (stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: complex FM I/Q -> chip x16_in (shared duplex port, stream 'rx')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    output_words: '"q15"'
    stream_id: '"rx"'
  states: {}
- name: tx_audio
  id: blocks_vector_source_x
  parameters:
    comment: TX audio (two tones) -> chip (stream 'tx'); finite, no repeat
    repeat: 'False'
    type: float
    vector: stim.tx_audio(n_samp)
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: FM passband (TX)
    name: FM passband (TX)
    size: stim.points(n_samp)
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: FM passband (I/Q interleaved) <- chip x16_out (stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: TX audio -> chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"tx"'
  states: {}
- name: tx_vco
  id: kyttar_frequency_modulator
  parameters:
    comment: 'FM modulate (sensitivity = 2*pi*f_dev/fs): phi += sensitivity*audio'
    device_id: '"kyttar_0"'
    sensitivity: '0.2945243112740431'
  states: {}

connections:
- [fm_rf, '0', rx_src, '0']
- [rx_demod, '0', rx_sink, '0']
- [rx_sink, '0', rx_audio, '0']
- [rx_src, '0', rx_demod, '0']
- [tx_audio, '0', tx_src, '0']
- [tx_sink, '0', tx_passband, '0']
- [tx_src, '0', tx_vco, '0']
- [tx_vco, '0', tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
