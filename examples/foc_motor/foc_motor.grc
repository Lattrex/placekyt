options:
  parameters:
    author: Lattrex
    description: 'THE FULL FOC CURRENT LOOP as a logical flowgraph: the measurement half (Clarke + forward Park), the host-side error former, and the command half (two PI controllers + inverse Park + SVPWM), closed around an an embedded PMSM plant so the loop actually runs. THE LOOP CLOSES INSIDE ONE HOST BLOCK. GNU Radio''s stream scheduler forbids cycles outright -- a stream ring is refused at start() with ''flow graph has loops!'', and no buffer sizing fixes it -- so the motor, the error former and the feedback path all live in a single stateful block, foc_host, which therefore has NO stream inputs. The graph the scheduler sees is a TREE: foc_host at the root, the measurement half and the command half hanging off it as feed-forward branches. Every word foc_host emits is the LIVE value of that wire in the loop it is running now, computed this period from the previous period''s duties -- this is a genuinely closed loop, not a replay of a canned recording. PLACEMENT IS THE READER''S JOB AND THIS FILE DOES NOT PRESUME IT. The whole loop does NOT route on one 10x12 array: the limit is corridor/arm budget, not cells (the full chain is 55 block cells of 120, yet the best of ~2600 whole-chain placements still left 2 of 13 nets unrouted, and the unrouted nets were always rendezvous arms). The NATURAL SPLIT is the measurement half on one die and the command half on another; the two halves are joined only by (i_d, i_q) out and (e_d, e_q) back, plus theta, so the crossing is narrow. A chip crossing costs about 40 ns, which is negligible against the ~35 us loop period. RATE: the command half alone measures 55.8 kHz sustained on one array. The two halves are strictly SERIAL within a sample -- sample k''s duties cannot be computed until sample k''s currents have been measured and rotated -- so the whole loop is expected near 28 kHz, which is the number this flowgraph exists to let you verify. The chain RE-ARMS rather than pipelines: each rendezvous bars its arms until the current group has cleared, so one iteration is in flight at a time and the period equals whole-chain depth. EVERY ingress arm has its OWN kyttar_source with a DISTINCT stream id, and its OWN relay block: a net fanned straight off the input port lands every word on the port cell, hence on ONE face, which the rendezvous LOCK bars -- the chain then builds, routes and emits nothing. THETA fans out to BOTH rotations and therefore has TWO sources and TWO relays, one per consumer. SVPWM emits THREE words per sample (duty a, b, c) on one stream, so its sink is set to q15 output words and split with a Deinterleave at 3. SINK PAIRING: each kyttar_sink names the stream id of the source that HEADS its chain -- sink_idq takes ''ia'' and sink_duty takes ''e_d'' -- following the shipped multi-stream convention. Note that each chain here is fed by THREE arms rather than one, so if you re-tag the arms when you place this, keep each sink''s id equal to its chain''s head source.'
    generate_options: qt_gui
    id: foc_motor
    output_language: python
    title: FOC motor control — the FULL current loop
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'the CONTROL-LOOP rate the full loop targets: 28.6 kHz, i.e. a 35 us period. The command half alone measures 55.8 kHz; the two halves are serial within a sample.'
    value: '28600'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: 'control iterations per burst. Sized to the settle horizon: the closed loop reaches 2% of the q-axis reference by about step 432 with the shipped conservative ki.'
    value: '600'
  states: {}
- name: i_q_ref
  id: variable
  parameters:
    comment: the TORQUE command, as a Q15 fraction of full-scale current (0.30 = 3 A at the 10 A i_base). This is what an outer speed loop would drive.
    value: '0.3'
  states: {}
- name: i_d_ref
  id: variable
  parameters:
    comment: 'the d-axis (flux) reference. ZERO for a surface PMSM: the magnets already supply the rotor flux, so d-axis current is pure loss. Field weakening would drive it negative.'
    value: '0.0'
  states: {}
- name: foc_host
  id: epy_block
  parameters:
    _source_code: |
      """THE HOST SIDE OF THE LOOP — plant, error former and the FEEDBACK PATH,
      in ONE stateful block.

      WHY ONE BLOCK. GNU Radio's stream scheduler forbids cycles outright, and a
      control loop IS a cycle: the duties drive the motor, the motor's sensed
      currents drive the next period's duties. Wiring that as streams — a plant
      block here, an error former there, the array between them — asks the
      scheduler for a ring, and it refuses at start() with "flow graph has loops!".
      No buffer sizing fixes it; there is no priming that makes a stream ring legal.

      So the ring is closed INSIDE this block instead. It holds every piece of loop
      state that has to persist from one control period to the next — the motor's
      two stationary-frame currents and its rotor angle, and the two PI
      controllers' 32-bit integrators — and advances the WHOLE period in one step:

          sensed (ia, ib, theta)            [this block's motor state]
            -> Clarke -> forward Park       [the measurement half's models]
            -> e = ref - measured           [the error former]
            -> PI(d), PI(q) -> inverse Park -> SVPWM     [the command half's models]
            -> three duties -> the motor    [the plant update]

      Because the feedback is an internal assignment rather than a stream, this
      block has NO stream inputs at all. Everything it emits is an OUTPUT, so the
      flowgraph the scheduler sees is a tree: this block at the root, the two
      on-chip halves hanging off it as feed-forward branches. That is the whole
      trick, and it is what GNU Radio users conventionally do with a control loop.

      WHAT THE ARRAY THEN DOES. The chip branches are not decoration and they are
      not replay of a canned recording: every word this block emits is the live
      value of that wire in the loop it is running right now, computed this period
      from the previous period's duties. The array recomputes the measurement half
      from the sensed currents and the command half from the errors, and the scopes
      show what came BACK off the array. The loop is genuinely closed; the array
      sits across it rather than inside the scheduler's ring.

      THE MOTOR MODEL. Surface PMSM (Ld == Lq) in the stationary two-phase frame,
      forward Euler at the control period dt:

          L d(i_alpha)/dt = v_alpha - R*i_alpha - e_alpha
          L d(i_beta )/dt = v_beta  - R*i_beta  - e_beta

      with a sinusoidal machine's back-EMF

          e_alpha = -ke*omega_e*sin(theta_e)
          e_beta  = +ke*omega_e*cos(theta_e)

      and theta_e advancing at a constant electrical speed omega_e.

      WHAT IS HELD CONSTANT, and why that is honest: the mechanical dynamics.
      omega_e does not respond to the torque the loop produces. A current loop
      closes two to three orders of magnitude faster than any real machine's
      mechanical pole, so constant speed over a current-loop settle is the standard
      modelling assumption. This is a CURRENT-loop model, not a drivetrain.

      The inverter is ideal: duty cycles are taken as applied phase voltages scaled
      by v_dc. No dead time, no device drop, no switching ripple — those change a
      real drive's current ripple, not whether the regulator regulates.

      THE ERROR FORMER is on the host BY CONSTRUCTION, not by omission: the
      reference is a supervisory quantity (a torque command from an outer speed
      loop, or an operator setpoint), it changes on a far slower timescale than the
      current loop, and putting a two-input subtract on the array would spend a
      rendezvous — the scarcest resource in this design — on an operation the host
      does for free between bursts. i_d_ref is ZERO for a surface PMSM: the magnets
      already supply the rotor flux, so any d-axis current is pure loss.

      THE INTEGRATOR TRAP, stated because it is silent when you hit it: the PI
      block's batch reference model keeps its 32-bit accumulator LOCAL to the call,
      so stepping it one sample at a time deletes the integral action entirely —
      the loop then runs proportional-only, settles short of its reference, and
      changing ki changes nothing at all. StatefulPI carries the accumulator across
      calls, and that is what this block steps.

      WIRE FORMAT, unchanged on every port: currents are Q15 fractions of i_base,
      the angle is the 16-bit half-turn convention as a Q15 float in [-1, 1)
      (value = theta/pi), duties are Q15. That is exactly what the kyttar sources
      inject.
      """
      import os
      import sys

      import numpy as np
      from gnuradio import gr

      # The loop's arithmetic is the SHIPPED models — the same integer models the
      # gates and the two-array harness use — rather than a second transcription
      # that could drift from them.
      # GRC EVALUATES THIS SOURCE AT EDIT TIME, in a namespace with no __file__, so
      # the import path is discovered by SEARCH rather than relative to this file: an
      # unguarded __file__ here makes GRC fail to interpret the source, the block
      # then declares no ports, and every connection to it is reported unmakeable.
      def _add_model_paths():
          seen = set(sys.path)
          roots = []
          for base in [os.getcwd()] + [p for p in sys.path if p]:
              try:
                  base = os.path.abspath(base)
              except Exception:
                  continue
              d = base
              for _ in range(6):
                  if d in roots:
                      break
                  roots.append(d)
                  nxt = os.path.dirname(d)
                  if nxt == d:
                      break
                  d = nxt
          for r in roots:
              cand = [os.path.join(r, 'examples', 'foc_motor'),
                      os.path.join(r, 'runtime', 'python'),
                      os.path.join(r, 'verification', 'tests')]
              if not os.path.isfile(os.path.join(cand[0], 'foc_loop_model.py')):
                  continue
              for c in cand:
                  if c not in seen and os.path.isdir(c):
                      sys.path.insert(0, c)
                      seen.add(c)
              return True
          return False


      _add_model_paths()

      from foc_loop_model import (PMSMPlant, MotorParams, StatefulPI, DEFAULT_PI,
                                  foc_loop_golden, q15, from_q15)


      class blk(gr.sync_block):
          """The host half of the loop: motor + error former + feedback, no inputs.

          Eleven outputs, all of them a live wire of the running loop:

              0 ia          1 ib          2 theta      -> the measurement half
              3 e_d         4 e_q         5 theta      -> the command half
              6 i_d         7 i_q                      -> the host's own monitors
              8 duty_a      9 duty_b     10 duty_c     -> what drove the motor

          theta is emitted TWICE because it feeds BOTH rotations, and on-chip
          fan-out to two rendezvous arms is the hard part — so it is delivered as
          two independent ingress arms, one per consumer.
          """

          def __init__(self, r_s=0.35, l_s=1.5e-3, ke=0.035, v_dc=24.0,
                       i_base=10.0, omega_e=200.0, dt=35e-6,
                       kp=0.25, ki=0.01, limit=1.0,
                       i_d_ref=0.0, i_q_ref=0.30):
              gr.sync_block.__init__(
                  self, name='FOC host loop (motor + error + feedback)',
                  in_sig=[],
                  out_sig=[np.float32] * 11)
              self.params = MotorParams(r_s=float(r_s), l_s=float(l_s),
                                        ke=float(ke), v_dc=float(v_dc),
                                        i_base=float(i_base))
              self.plant = PMSMPlant(params=self.params, dt=float(dt),
                                     omega_e=float(omega_e))
              pi = dict(DEFAULT_PI)
              pi.update(kp=float(kp), ki=float(ki), limit=float(limit))
              self.pi_d = StatefulPI('d', **pi)
              self.pi_q = StatefulPI('q', **pi)
              self.i_d_ref = float(i_d_ref)
              self.i_q_ref = float(i_q_ref)
              # The sensed state the FIRST control period is computed from: the
              # motor at rest. Every later period reads what the previous period's
              # duties left behind — that is the closed loop.
              self._sensed = self.plant.sensed_words()

          def work(self, input_items, output_items):
              n = len(output_items[0])
              ref_d = q15(self.i_d_ref)
              ref_q = q15(self.i_q_ref)
              for k in range(n):
                  ia_w, ib_w, th_w = self._sensed

                  # ONE whole control period, every on-chip stage computed by that
                  # block's own pinned integer model, with the LIVE integrators.
                  da, db, dc, i_d, i_q = foc_loop_golden(
                      ia_w, ib_w, th_w, ref_d, ref_q, self.pi_d, self.pi_q)

                  e_d = from_q15(ref_d) - from_q15(i_d)
                  e_q = from_q15(ref_q) - from_q15(i_q)
                  lim = 32767.0 / 32768.0
                  e_d = min(max(e_d, -1.0), lim)
                  e_q = min(max(e_q, -1.0), lim)

                  # the measurement half's three ingress arms
                  output_items[0][k] = from_q15(ia_w)
                  output_items[1][k] = from_q15(ib_w)
                  output_items[2][k] = from_q15(th_w)
                  # the command half's three ingress arms
                  output_items[3][k] = e_d
                  output_items[4][k] = e_q
                  output_items[5][k] = from_q15(th_w)
                  # the host's own view of the loop
                  output_items[6][k] = from_q15(i_d)
                  output_items[7][k] = from_q15(i_q)
                  output_items[8][k] = from_q15(da)
                  output_items[9][k] = from_q15(db)
                  output_items[10][k] = from_q15(dc)

                  # CLOSE THE LOOP: this period's duties drive the motor, and what
                  # it then senses is what the NEXT period is computed from. This
                  # assignment is the feedback path — the thing that would be a
                  # stream cycle if it were wired instead of held.
                  self._sensed = self.plant.step(da, db, dc)
              return n
    comment: 'THE HOST SIDE — the motor, the error former and the feedback path in one stateful block. Nothing here is on the chip and nothing here ever will be. It has no inputs on purpose: the loop closes INSIDE it, which is what keeps the flowgraph acyclic and startable.'
    r_s: '0.35'
    l_s: '1.5e-3'
    ke: '0.035'
    v_dc: '24.0'
    i_base: '10.0'
    omega_e: '200.0'
    dt: 1.0/samp_rate
    kp: '0.25'
    ki: '0.01'
    limit: '1.0'
    i_d_ref: i_d_ref
    i_q_ref: i_q_ref
  states: {}
- name: src_ia
  id: kyttar_source
  parameters:
    comment: 'ingress arm: phase current ia. Its own stream id so the server resolves this burst to the ia arm''s own entry/hop/data registers.'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"ia"'
  states: {}
- name: src_ib
  id: kyttar_source
  parameters:
    comment: 'ingress arm: phase current ib. The two-shunt FOC front end senses only ia and ib; with ia+ib+ic=0 the third is redundant.'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"ib"'
  states: {}
- name: relay_ia
  id: kyttar_splitter
  parameters:
    comment: 'per-arm relay (INV-71): without it this arm lands on the port cell and shares a face with the others, which the Clarke rendezvous LOCK bars.'
    device_id: '"kyttar_0"'
  states: {}
- name: relay_ib
  id: kyttar_splitter
  parameters:
    comment: per-arm relay (INV-71) — see relay_ia.
    device_id: '"kyttar_0"'
  states: {}
- name: clarke
  id: kyttar_clarke_transform
  parameters:
    comment: 'ON CHIP: the amplitude-invariant two-current Clarke. i_alpha = ia; i_beta = (ia + 2*ib)/sqrt(3). One cell, a two-arm face-locking rendezvous — the two inputs MUST reach it on two different faces.'
    device_id: '"kyttar_0"'
  states: {}
- name: ab_split
  id: blocks_complex_to_float
  parameters:
    comment: type glue only — the importer splices this out, wiring Clarke's I rail to the rotation's x and its Q rail to y. No cell is spent.
  states: {}
- name: src_th_park
  id: kyttar_source
  parameters:
    comment: 'ingress arm: rotor electrical angle theta for the FORWARD Park rotation. theta feeds BOTH rotations, and on-chip fan-out to two rendezvous arms is the hard part — so it is delivered as TWO independent ingress arms, one per consumer, each with its own stream id and its own relay.'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"th_park"'
  states: {}
- name: relay_th_park
  id: kyttar_splitter
  parameters:
    comment: per-arm relay for the forward Park's theta arm.
    device_id: '"kyttar_0"'
  states: {}
- name: park
  id: kyttar_cordic_rotate
  parameters:
    comment: 'ON CHIP: the FORWARD Park rotation, sign = -1 (rotate by -theta). Takes the measured stationary-frame current vector into the rotor frame, where the torque- and flux-producing components separate. A THREE-arm rendezvous: x, y and theta must land on three distinct faces.'
    device_id: '"kyttar_0"'
    sign: '-1'
  states: {}
- name: sink_idq
  id: kyttar_sink
  parameters:
    comment: 'drains the measurement half''s result: the rotor-frame currents (i_d, i_q) interleaved. Q15 floats — the sink emits word/32768.'
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"ia"'
  states: {}
- name: idq_split
  id: blocks_deinterleave
  parameters:
    comment: split the recovered interleaved [i_d, i_q, i_d, i_q, ...] float stream into the two rails the error former subtracts from. The kyttar sink emits FLOAT even for a complex on-chip stream — the rails come back interleaved.
    type: float
  states: {}
- name: src_ed
  id: kyttar_source
  parameters:
    comment: 'ingress arm: the d-axis current error into PI(d).'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"e_d"'
  states: {}
- name: src_eq
  id: kyttar_source
  parameters:
    comment: 'ingress arm: the q-axis current error into PI(q).'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"e_q"'
  states: {}
- name: relay_ed
  id: kyttar_splitter
  parameters:
    comment: per-arm relay (INV-71) for the e_d arm.
    device_id: '"kyttar_0"'
  states: {}
- name: relay_eq
  id: kyttar_splitter
  parameters:
    comment: per-arm relay (INV-71) for the e_q arm.
    device_id: '"kyttar_0"'
  states: {}
- name: pi_d
  id: kyttar_pi_controller
  parameters:
    comment: 'ON CHIP: the d-axis current PI. 32-bit anti-windup integrator — the one place 16 bits is NOT enough: ki*e per step can fall below one Q15 LSB and would vanish silently in a 16-bit accumulator. Both axes share the tuning because Ld == Lq on a surface PMSM.'
    device_id: '"kyttar_0"'
    kp: '0.25'
    ki: '0.01'
    limit: '1.0'
  states: {}
- name: pi_q
  id: kyttar_pi_controller
  parameters:
    comment: 'ON CHIP: the q-axis current PI. 32-bit anti-windup integrator — the one place 16 bits is NOT enough: ki*e per step can fall below one Q15 LSB and would vanish silently in a 16-bit accumulator. Both axes share the tuning because Ld == Lq on a surface PMSM.'
    device_id: '"kyttar_0"'
    kp: '0.25'
    ki: '0.01'
    limit: '1.0'
  states: {}
- name: src_th_ipark
  id: kyttar_source
  parameters:
    comment: 'ingress arm: theta for the INVERSE Park rotation — the second of theta''s two independent deliveries.'
    burst_len: '600'
    complex_in: float
    device_id: '"kyttar_0"'
    max_events_per: '2000000'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"th_ipark"'
  states: {}
- name: relay_th_ipark
  id: kyttar_splitter
  parameters:
    comment: per-arm relay for the inverse Park's theta arm.
    device_id: '"kyttar_0"'
  states: {}
- name: ipark
  id: kyttar_cordic_rotate
  parameters:
    comment: 'ON CHIP: the INVERSE Park rotation, sign = +1 (rotate by +theta). Carries the rotor-frame voltage command (v_d, v_q) back to the stationary frame as (v_alpha, v_beta). A THREE-arm rendezvous.'
    device_id: '"kyttar_0"'
    sign: '1'
  states: {}
- name: v_split
  id: blocks_complex_to_float
  parameters:
    comment: type glue — spliced out by the importer; the rotation's I rail becomes v_alpha and its Q rail v_beta.
  states: {}
- name: svpwm
  id: kyttar_svpwm
  parameters:
    comment: 'ON CHIP: space-vector PWM by min-max (common-mode) injection. Emits THREE words per sample on ONE stream, fixed order a, b, c — hence the q15 sink and the Deinterleave at 3 downstream. The midpoint injection buys SVPWM its ~15.5% linear-range advantage over sine PWM.'
    device_id: '"kyttar_0"'
  states: {}
- name: sink_duty
  id: kyttar_sink
  parameters:
    comment: 'drains the SVPWM duty stream: three Q15 words per control period, order a, b, c.'
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"e_d"'
  states: {}
- name: duty_split
  id: blocks_deinterleave
  parameters:
    comment: split the 3-word duty packet into the three per-phase duty streams. Deinterleave at 3 is the documented way to unpack this block's output.
    num_streams: '3'
    type: float
  states: {}
- name: scope_idq
  id: qtgui_time_sink_x
  parameters:
    comment: 'THE DEMO PLOT — the loop regulating. i_q climbs to the torque reference and i_d is held at zero. FOUR traces: the two the ARRAY returned and the two the host computed for the same control periods, so the array''s measurement half is checked against its own golden on screen rather than merely displayed. The buffer is a FULL burst: a short buffer paints nothing when the batch arrives at once, and the kyttar sink emits q15/32768 floats, so the y axis is in Q15 units.'
    grid: 'True'
    name: '"rotor-frame currents i_d, i_q — array vs host (Q15)"'
    nconnections: '4'
    size: burst_len
    srate: samp_rate
    type: float
    ylabel: current (Q15 fraction of full scale)
    ymax: '0.6'
    ymin: '-0.6'
    label1: i_d (array)
    label2: i_q (array)
    label3: i_d (host)
    label4: i_q (host)
  states: {}
- name: scope_duty
  id: qtgui_time_sink_x
  parameters:
    comment: the three SVPWM duty cycles — the min-max injected set the inverter legs actually switch on — as the ARRAY returned them, over the three the host computed for the same periods. The host set is the one that actually drove the motor this run; the array set is the check on it.
    grid: 'True'
    name: '"inverter duty cycles a, b, c — array vs host (Q15)"'
    nconnections: '6'
    size: burst_len
    srate: samp_rate
    type: float
    ylabel: duty (Q15)
    ymax: '0.7'
    ymin: '-0.7'
    label1: duty a (array)
    label2: duty b (array)
    label3: duty c (array)
    label4: duty a (host)
    label5: duty b (host)
    label6: duty c (host)
  states: {}
- name: scope_err
  id: qtgui_time_sink_x
  parameters:
    comment: the two current errors driving the PI controllers — both converge to zero as the loop settles.
    grid: 'True'
    name: '"current errors e_d, e_q (Q15)"'
    nconnections: '2'
    size: burst_len
    srate: samp_rate
    type: float
    ylabel: error (Q15)
    ymax: '0.6'
    ymin: '-0.6'
    label1: e_d
    label2: e_q
  states: {}

connections:
- [foc_host, '0', src_ia, '0']
- [foc_host, '1', src_ib, '0']
- [foc_host, '2', src_th_park, '0']
- [src_ia, '0', relay_ia, '0']
- [src_ib, '0', relay_ib, '0']
- [relay_ia, '0', clarke, '0']
- [relay_ib, '0', clarke, '1']
- [clarke, '0', ab_split, '0']
- [ab_split, '0', park, '0']
- [ab_split, '1', park, '1']
- [src_th_park, '0', relay_th_park, '0']
- [relay_th_park, '0', park, '2']
- [park, '0', sink_idq, '0']
- [sink_idq, '0', idq_split, '0']
- [foc_host, '3', src_ed, '0']
- [foc_host, '4', src_eq, '0']
- [foc_host, '5', src_th_ipark, '0']
- [src_ed, '0', relay_ed, '0']
- [src_eq, '0', relay_eq, '0']
- [relay_ed, '0', pi_d, '0']
- [relay_eq, '0', pi_q, '0']
- [pi_d, '0', ipark, '0']
- [pi_q, '0', ipark, '1']
- [src_th_ipark, '0', relay_th_ipark, '0']
- [relay_th_ipark, '0', ipark, '2']
- [ipark, '0', v_split, '0']
- [v_split, '0', svpwm, '0']
- [v_split, '1', svpwm, '1']
- [svpwm, '0', sink_duty, '0']
- [sink_duty, '0', duty_split, '0']
- [idq_split, '0', scope_idq, '0']
- [idq_split, '1', scope_idq, '1']
- [duty_split, '0', scope_duty, '0']
- [duty_split, '1', scope_duty, '1']
- [duty_split, '2', scope_duty, '2']
- [foc_host, '6', scope_idq, '2']
- [foc_host, '7', scope_idq, '3']
- [foc_host, '8', scope_duty, '3']
- [foc_host, '9', scope_duty, '4']
- [foc_host, '10', scope_duty, '5']
- [foc_host, '3', scope_err, '0']
- [foc_host, '4', scope_err, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
