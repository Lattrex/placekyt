options:
  parameters:
    author: Lattrex
    description: 'Full-duplex M17 4FSK (C4FM) modem authored in GNU Radio (GRC-first workflow). The TX chain (4FSK symbol mapper -> upsampler -> RRC pulse shaper -> frequency modulator) and the RX chain (quadrature demod -> RRC matched filter -> 4FSK sync-word timing recovery -> 4FSK slicer) live on ONE placeKYT array, sharing ONE input port (x16_in) and ONE output port (x16_out): both TX and RX source blocks map to x16_in and both sink blocks map to x16_out (the shared-port duplex). Gardner does NOT lock a 4-level FSK signal, so timing is recovered by SYNC-WORD CORRELATION (the M17 LSF sync word) -- exactly what real M17 receivers do. Built from the REAL DSP blocks so it IMPORTS into placeKYT (File -> Import GNURadio Flowgraph) and recovers the M17 dibits at BER 0.'
    generate_options: qt_gui
    id: fsk4_modem
    output_language: python
    run_options: run
    title: Full-duplex M17 4FSK modem (TX + sync-timed RX on one array)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate for the sinks
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples/symbol (on-chip operating point)
    value: '2'
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: RX payload symbols in the burst
    value: '160'
  states: {}
- name: n_bits
  id: variable
  parameters:
    comment: TX payload bits in the burst (2/symbol)
    value: '64'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    comment: FM sensitivity 2*pi*2400/9600 = pi/2 (+3 -> 2400 Hz)
    value: '1.5707963267948966'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import fsk4_demo_stim as stim
  states: {}
- name: tx_iq_split
  id: blocks_deinterleave
  parameters:
    comment: split the kyttar sink's interleaved [I0,Q0,I1,Q1,...] float stream into SEPARATE I (ch0) and Q (ch1) float streams for the TX baseband plot
    type: float
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    comment: TX 4FSK COMPLEX baseband shown as SEPARATE I (blue) and Q (red) traces (de-interleaved from the kyttar sink's [I0,Q0,...] float stream)
    label1: I
    label2: Q
    name: '"TX baseband I/Q"'
    nconnections: '2'
    size: stim.tx_pb_points(n_bits)
    srate: samp_rate
    type: float
    ylabel: amplitude
    grid_style1: solid
    grid_style2: solid
  states: {}
- name: rx_syms
  id: qtgui_time_sink_x
  parameters:
    color1: green
    comment: recovered 4FSK dibits (0..3)
    label1: dibit
    name: '"Recovered dibits"'
    size: stim.rx_syms_points(n_syms)
    srate: samp_rate
    type: float
    ylabel: dibit
    ymax: '3'
    ymin: '0'
    grid_style1: solid
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bit stimulus (preamble+sync+payload; one finite burst, no repeat)
    repeat: 'False'
    type: float
    vector: stim.tx_bits(n_bits)
  states: {}
- name: tx_syms_src
  id: blocks_vector_source_x
  parameters:
    comment: transmitted DIBITS (0..3) — same burst as tx_bits, packed 2 bits/symbol
    repeat: 'False'
    type: float
    vector: stim.tx_syms(n_bits)
  states: {}
- name: tx_syms
  id: qtgui_time_sink_x
  parameters:
    comment: transmitted 4FSK dibits (0..3) — compare with 'Recovered dibits'
    label1: dibit
    name: '"Transmitted dibits"'
    size: stim.tx_syms_points(n_bits)
    srate: samp_rate
    type: float
    ylabel: dibit
    ymax: '3'
    ymin: '0'
    grid_style1: solid
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: len(stim.tx_bits(n_bits))
    comment: TX bits -> placeKYT chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: mapper
  id: kyttar_fsk4_symbol_mapper
  parameters:
    comment: 4FSK symbol mapper (bits -> PAM level) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: up
  id: kyttar_upsampler
  parameters:
    comment: Zero-stuff upsampler (sps) -- placed on chip
    device_id: '"kyttar_0"'
    io_type: float
    sps: '2'
  states: {}
- name: rrc
  id: kyttar_rrc_pulse_shaper
  parameters:
    alpha: '0.5'
    comment: RRC pulse shaper -- placed on chip
    device_id: '"kyttar_0"'
    gain: '1.0'
    io_type: float
    ntaps: '17'
    sampling_freq: '2.0'
    symbol_rate: '1.0'
  states: {}
- name: fm
  id: kyttar_frequency_modulator
  parameters:
    comment: FM modulator (PAM level -> passband) -- placed on chip
    device_id: '"kyttar_0"'
    sensitivity: '1.5707963267948966'
    pipeline_lock: 'True'
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: TX complex baseband I/Q -> placeKYT chip x16_out (shared duplex port, stream 'tx'; the FM yi/yq rails egress on out_tag / out_tag+1)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: RX 4FSK FM burst (preamble+sync+payload); finite, no repeat
    repeat: 'False'
    type: complex
    vector: stim.burst(n_syms)
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: stim.burst_len(n_syms)
    comment: RX I/Q burst -> placeKYT chip x16_in (shared duplex port, stream 'rx')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: qd
  id: kyttar_quadrature_demod
  parameters:
    comment: FM discriminator (complex -> real level) -- placed on chip
    device_id: '"kyttar_0"'
    gain: '1.0'
  states: {}
- name: mf
  id: kyttar_rrc_pulse_shaper
  parameters:
    alpha: '0.5'
    comment: RRC matched filter -- placed on chip
    device_id: '"kyttar_0"'
    gain: '1.0'
    io_type: float
    ntaps: '17'
    sampling_freq: '2.0'
    symbol_rate: '1.0'
  states: {}
- name: timing
  id: kyttar_fsk4_sync_timing_recovery
  parameters:
    comment: 4FSK sync-word timing recovery (M17 correlation) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: slicer
  id: kyttar_fsk4_slicer
  parameters:
    comment: 4FSK slicer (recovered dibits) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered dibits -> placeKYT chip x16_out (shared duplex port, stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}

connections:
- [tx_bits, '0', tx_src, '0']
- [tx_syms_src, '0', tx_syms, '0']
- [tx_src, '0', mapper, '0']
- [mapper, '0', up, '0']
- [up, '0', rrc, '0']
- [rrc, '0', fm, '0']
- [fm, '0', tx_sink, '0']
- [tx_sink, '0', tx_iq_split, '0']
- [tx_iq_split, '0', tx_passband, '0']
- [tx_iq_split, '1', tx_passband, '1']
- [rx_iq, '0', rx_src, '0']
- [rx_src, '0', qd, '0']
- [qd, '0', mf, '0']
- [mf, '0', timing, '0']
- [timing, '0', slicer, '0']
- [slicer, '0', rx_sink, '0']
- [rx_sink, '0', rx_syms, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
