options:
  parameters:
    author: Lattrex
    description: MINIMAL Kyttar Gain demo (GRC-first socket-streaming workflow). A slow sine stimulus -> kyttar_source (x16_in) -> kyttar_gain (0.5) -> kyttar_sink (x16_out) -> QT time sink. Run as GNURadio Server in placeKYT, set server_port below to the printed port, then Execute here. The time sink shows the INPUT sine (top trace) versus the chip OUTPUT (input * 0.5), so the user SEES the gain take effect.
    generate_options: qt_gui
    id: gain_demo
    output_language: python
    title: Kyttar Gain demo — input vs gained output (gain=0.5)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: src
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    comment: slow sine stimulus in [-1,1] into the chip
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    comment: stimulus -> placeKYT chip x16_in
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    complex_in: 'False'
  states: {}
- name: gain
  id: kyttar_gain
  parameters:
    comment: gain = 0.5 (placed on chip)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: gained output <- placeKYT chip x16_out
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input (top) vs gained output (input * 0.5)
    grid: 'True'
    label1: input
    label2: output (gain=0.5)
    name: '"Kyttar Gain: input vs output"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [src, '0', msrc, '0']
- [src, '0', time_sink, '0']
- [msrc, '0', gain, '0']
- [gain, '0', msink, '0']
- [msink, '0', time_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
