options:
  parameters:
    author: Lattrex
    description: MINIMAL Kyttar Gain demo (GRC-first socket-streaming workflow). A slow sine stimulus -> kyttar_source (x16_in) -> kyttar_gain (0.5) -> kyttar_sink (x16_out) -> QT time sink. Run as GNURadio Server in placeKYT, set server_port below to the printed port, then Execute here. The time sink shows the INPUT sine (top trace) versus the chip OUTPUT (input * 0.5), so the user SEES the gain take effect.
    generate_options: qt_gui
    id: gain_demo
    output_language: python
    title: Kyttar Gain demo — input vs gained output (gain=0.5)
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    comment: fixed burst length (float samples) dispatched to the chip in one RPC
    value: '256'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: gain
  id: kyttar_gain
  parameters:
    comment: gain = 0.5 (placed on chip)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: gained output <- placeKYT chip x16_out
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: ''
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stimulus -> placeKYT chip x16_in (batch); dispatches one bounded burst
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: bounded slow-sine burst (one fixed-length vector) into the chip — REPEAT so the flowgraph never reaches EOF; the Kyttar Source accumulates exactly one burst, dispatches it ONCE via process_batch, then the Sink re-emits the gained result for a stable live plot.
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*2*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input (top) vs gained output (input * 0.5)
    grid: 'True'
    label1: input
    label2: output (gain=0.5)
    name: '"Kyttar Gain: input vs output"'
    nconnections: '2'
    size: '256'
    srate: '1'
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [gain, '0', msink, '0']
- [msink, '0', time_sink, '1']
- [msrc, '0', gain, '0']
- [src, '0', msrc, '0']
- [src, '0', time_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
