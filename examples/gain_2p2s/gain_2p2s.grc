options:
  parameters:
    author: Lattrex
    description: '2P2S multi-chip demo: FOUR gain streams (one per chip) across two parallel daisy-chains, multiplexed over the placeKYT multi-chip GNURadio server. Each stream -> 0.5x.'
    generate_options: qt_gui
    id: gain_2p2s_demo
    output_language: python
    title: Kyttar 2P2S — four multiplexed gain streams (0.5x each)
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: gain_a
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream A (chip0's cell)
    label: gain A (chip0, live)
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: gain_b
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream B (chip1's cell)
    label: gain B (chip1, live)
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: gain_c
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream C (chip2's cell)
    label: gain C (chip2, live)
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: gain_d
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream D (chip3's cell)
    label: gain D (chip3, live)
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT's default host port (Run as GNURadio Server binds 58950; change if it prints another)
    value: '58950'
  states: {}
- name: gainA
  id: kyttar_gain
  parameters:
    block_name: '"gain"'
    comment: live gain (chip0 = gain)
    device_id: '"kyttar_0"'
    gain: gain_a
  states: {}
- name: gainB
  id: kyttar_gain
  parameters:
    block_name: '"gain_1"'
    comment: live gain (chip1 = gain_1)
    device_id: '"kyttar_0"'
    gain: gain_b
  states: {}
- name: gainC
  id: kyttar_gain
  parameters:
    block_name: '"gain_2"'
    comment: live gain (chip2 = gain_2)
    device_id: '"kyttar_0"'
    gain: gain_c
  states: {}
- name: gainD
  id: kyttar_gain
  parameters:
    block_name: '"gain_3"'
    comment: live gain (chip3 = gain_3)
    device_id: '"kyttar_0"'
    gain: gain_d
  states: {}
- name: msinkA
  id: kyttar_sink
  parameters:
    comment: stream A recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"A"'
  states: {}
- name: msinkB
  id: kyttar_sink
  parameters:
    comment: stream B recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"B"'
  states: {}
- name: msinkC
  id: kyttar_sink
  parameters:
    comment: stream C recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"C"'
  states: {}
- name: msinkD
  id: kyttar_sink
  parameters:
    comment: stream D recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"D"'
  states: {}
- name: msrcA
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream A -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'yes'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"A"'
  states: {}
- name: msrcB
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream B -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'yes'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"B"'
  states: {}
- name: msrcC
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream C -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'yes'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"C"'
  states: {}
- name: msrcD
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream D -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'yes'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"D"'
  states: {}
- name: srcA
  id: blocks_vector_source_x
  parameters:
    comment: stream A sine (taps chip0's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*2*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: srcB
  id: blocks_vector_source_x
  parameters:
    comment: stream B sine (taps chip1's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*3*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: srcC
  id: blocks_vector_source_x
  parameters:
    comment: stream C sine (taps chip2's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*4*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: srcD
  id: blocks_vector_source_x
  parameters:
    comment: stream D sine (taps chip3's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*5*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: time_sink_A
  id: qtgui_time_sink_x
  parameters:
    color2: blue
    comment: 'Stream A: input vs 0.5x'
    grid: 'True'
    label1: input
    label2: Stream A out (0.5x)
    name: '"Stream A"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: time_sink_B
  id: qtgui_time_sink_x
  parameters:
    comment: 'Stream B: input vs 0.5x'
    grid: 'True'
    label1: input
    label2: Stream B out (0.5x)
    name: '"Stream B"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: time_sink_C
  id: qtgui_time_sink_x
  parameters:
    color2: green
    comment: 'Stream C: input vs 0.5x'
    grid: 'True'
    label1: input
    label2: Stream C out (0.5x)
    name: '"Stream C"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: time_sink_D
  id: qtgui_time_sink_x
  parameters:
    color2: magenta
    comment: 'Stream D: input vs 0.5x'
    grid: 'True'
    label1: input
    label2: Stream D out (0.5x)
    name: '"Stream D"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}

connections:
- [gainA, '0', msinkA, '0']
- [gainB, '0', msinkB, '0']
- [gainC, '0', msinkC, '0']
- [gainD, '0', msinkD, '0']
- [msinkA, '0', time_sink_A, '1']
- [msinkB, '0', time_sink_B, '1']
- [msinkC, '0', time_sink_C, '1']
- [msinkD, '0', time_sink_D, '1']
- [msrcA, '0', gainA, '0']
- [msrcB, '0', gainB, '0']
- [msrcC, '0', gainC, '0']
- [msrcD, '0', gainD, '0']
- [srcA, '0', msrcA, '0']
- [srcA, '0', time_sink_A, '0']
- [srcB, '0', msrcB, '0']
- [srcB, '0', time_sink_B, '0']
- [srcC, '0', msrcC, '0']
- [srcC, '0', time_sink_C, '0']
- [srcD, '0', msrcD, '0']
- [srcD, '0', time_sink_D, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
