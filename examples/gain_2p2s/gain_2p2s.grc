options:
  parameters:
    author: Lattrex
    description: '2P2S multi-chip demo: FOUR gain streams (one per chip) across two parallel daisy-chains, multiplexed over the placeKYT multi-chip GNURadio server. Each stream -> 0.5x.'
    generate_options: qt_gui
    id: gain_2p2s_demo
    output_language: python
    title: Kyttar 2P2S — four multiplexed gain streams (0.5x each)
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: set to the port placeKYT prints
    value: '0'
  states: {}
- name: srcA
  id: blocks_vector_source_x
  parameters:
    comment: stream A sine (taps chip0's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*2*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcA
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream A -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"A"'
    pipelined: 'False'
    schedule: '"interleaved"'
  states: {}
- name: gainA
  id: kyttar_gain
  parameters:
    comment: gain 0.5 (chip0)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msinkA
  id: kyttar_sink
  parameters:
    comment: stream A recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"A"'
  states: {}
- name: time_sink_A
  id: qtgui_time_sink_x
  parameters:
    color2: blue
    label1: input
    label2: Stream A out (0.5x)
    comment: 'Stream A: input vs 0.5x'
    grid: 'True'
    name: '"Stream A"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: srcB
  id: blocks_vector_source_x
  parameters:
    comment: stream B sine (taps chip1's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*3*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcB
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream B -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"B"'
    pipelined: 'False'
    schedule: '"interleaved"'
  states: {}
- name: gainB
  id: kyttar_gain
  parameters:
    comment: gain 0.5 (chip1)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msinkB
  id: kyttar_sink
  parameters:
    comment: stream B recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"B"'
  states: {}
- name: time_sink_B
  id: qtgui_time_sink_x
  parameters:
    label1: input
    label2: Stream B out (0.5x)
    comment: 'Stream B: input vs 0.5x'
    grid: 'True'
    name: '"Stream B"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: srcC
  id: blocks_vector_source_x
  parameters:
    comment: stream C sine (taps chip2's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*4*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcC
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream C -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"C"'
    pipelined: 'False'
    schedule: '"interleaved"'
  states: {}
- name: gainC
  id: kyttar_gain
  parameters:
    comment: gain 0.5 (chip2)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msinkC
  id: kyttar_sink
  parameters:
    comment: stream C recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"C"'
  states: {}
- name: time_sink_C
  id: qtgui_time_sink_x
  parameters:
    color2: green
    label1: input
    label2: Stream C out (0.5x)
    comment: 'Stream C: input vs 0.5x'
    grid: 'True'
    name: '"Stream C"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: srcD
  id: blocks_vector_source_x
  parameters:
    comment: stream D sine (taps chip3's gain)
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*5*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcD
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream D -> placeKYT (stream_id only; chip/hop resolved there)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"D"'
    pipelined: 'False'
    schedule: '"interleaved"'
  states: {}
- name: gainD
  id: kyttar_gain
  parameters:
    comment: gain 0.5 (chip3)
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msinkD
  id: kyttar_sink
  parameters:
    comment: stream D recovered (0.5x)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"D"'
  states: {}
- name: time_sink_D
  id: qtgui_time_sink_x
  parameters:
    color2: magenta
    label1: input
    label2: Stream D out (0.5x)
    comment: 'Stream D: input vs 0.5x'
    grid: 'True'
    name: '"Stream D"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}

connections:
- [srcA, '0', msrcA, '0']
- [msrcA, '0', gainA, '0']
- [gainA, '0', msinkA, '0']
- [msinkA, '0', time_sink_A, '1']
- [srcA, '0', time_sink_A, '0']
- [srcB, '0', msrcB, '0']
- [msrcB, '0', gainB, '0']
- [gainB, '0', msinkB, '0']
- [msinkB, '0', time_sink_B, '1']
- [srcB, '0', time_sink_B, '0']
- [srcC, '0', msrcC, '0']
- [msrcC, '0', gainC, '0']
- [gainC, '0', msinkC, '0']
- [msinkC, '0', time_sink_C, '1']
- [srcC, '0', time_sink_C, '0']
- [srcD, '0', msrcD, '0']
- [msrcD, '0', gainD, '0']
- [gainD, '0', msinkD, '0']
- [msinkD, '0', time_sink_D, '1']
- [srcD, '0', time_sink_D, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
