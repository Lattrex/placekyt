options:
  parameters:
    author: Lattrex
    description: '2P2S multi-chip demo: two parallel gain daisy-chains driven over the placeKYT multi-chip GNURadio server. Each chain -> 0.25x.'
    generate_options: qt_gui
    id: gain_2p2s_demo
    output_language: python
    title: Kyttar 2P2S — two parallel chains (0.25x each)
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: set to the port placeKYT prints
    value: '0'
  states: {}
- name: srcA
  id: blocks_vector_source_x
  parameters:
    comment: chain A sine -> chip0 head
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*2*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcA
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream A -> chip0 (chain head)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"A"'
    pipelined: 'False'
    schedule: '"interleaved"'
    chip_id: '0'
    out_chip: '1'
    entry_addr: '28'
    hop_count: '30'
    data_addrs: '"0"'
  states: {}
- name: msinkA
  id: kyttar_sink
  parameters:
    comment: chain A tail (chip1 x16_out), 0.25x
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"A"'
  states: {}
- name: time_sink_A
  id: qtgui_time_sink_x
  parameters:
    color2: blue
    label1: input
    label2: chain A out (0.25x)
    comment: 'chain A: input vs 0.25x'
    grid: 'True'
    name: '"Chain A"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}
- name: srcB
  id: blocks_vector_source_x
  parameters:
    comment: chain B sine -> chip2 head
    repeat: 'True'
    type: float
    vector: '[0.8*float(__import__(''math'').sin(2*3.141592653589793*3*n/burst_len)) for n in range(burst_len)]'
  states: {}
- name: msrcB
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: stream B -> chip2 (chain head)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"B"'
    pipelined: 'False'
    schedule: '"interleaved"'
    chip_id: '2'
    out_chip: '3'
    entry_addr: '28'
    hop_count: '30'
    data_addrs: '"0"'
  states: {}
- name: msinkB
  id: kyttar_sink
  parameters:
    comment: chain B tail (chip3 x16_out), 0.25x
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"B"'
  states: {}
- name: time_sink_B
  id: qtgui_time_sink_x
  parameters:
    label1: input
    label2: chain B out (0.25x)
    comment: 'chain B: input vs 0.25x'
    grid: 'True'
    name: '"Chain B"'
    nconnections: '2'
    size: burst_len
    srate: burst_len
    type: float
  states: {}

connections:
- [srcA, '0', msrcA, '0']
- [msinkA, '0', time_sink_A, '1']
- [srcA, '0', time_sink_A, '0']
- [srcB, '0', msrcB, '0']
- [msinkB, '0', time_sink_B, '1']
- [srcB, '0', time_sink_B, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
