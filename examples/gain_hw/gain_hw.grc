options:
  parameters:
    author: Lattrex
    description: HARDWARE Kyttar TWO-GAIN MULTIPLEX demo. Two independent gain blocks share ONE input port (x16_in) and ONE output port (x16_out) on the same chip, distinguished by stream tags (stream_id "a"/"b") — the multiplexed shared-port model, like the AM/SSB transceiver examples. Each chain has its own sig_source, kyttar_source, kyttar_gain, kyttar_sink, and its own LIVE gain slider. Toggle Hardware Mode in placeKYT, Run as GNURadio Server, then Execute here. The plot shows both gained outputs; move each slider to retune that stream's gain live.
    generate_options: qt_gui
    id: gain_hw
    output_language: python
    title: Kyttar TWO-GAIN multiplex — HARDWARE streaming (live sliders)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: streaming sample rate into the chip (samples/s)
    value: '4000'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: gain_a
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream A (retunes cell A's coefficient)
    label: gain A
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: gain_b
  id: variable_qtgui_range
  parameters:
    comment: LIVE gain for stream B (retunes cell B's coefficient)
    label: gain B
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: src_a
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    comment: stream A stimulus (sine, freq 3)
    freq: '3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: msrc_a
  id: kyttar_source
  parameters:
    burst_len: '0'
    comment: stream A -> chip x16_in (stream_id "a")
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    repeat: 'yes'
    server_port: server_port
    stream_id: '"a"'
  states: {}
- name: gain_blk_a
  id: kyttar_gain
  parameters:
    block_name: '"gain"'
    comment: gain block A (live gain_a slider)
    device_id: '"kyttar_0"'
    gain: gain_a
  states: {}
- name: msink_a
  id: kyttar_sink
  parameters:
    comment: stream A output <- chip x16_out (stream_id "a")
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"a"'
  states: {}
- name: src_b
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    comment: stream B stimulus (sine, freq 7)
    freq: '7'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: msrc_b
  id: kyttar_source
  parameters:
    burst_len: '0'
    comment: stream B -> chip x16_in (stream_id "b")
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    repeat: 'yes'
    server_port: server_port
    stream_id: '"b"'
  states: {}
- name: gain_blk_b
  id: kyttar_gain
  parameters:
    block_name: '"gain_2"'
    comment: gain block B (live gain_b slider)
    device_id: '"kyttar_0"'
    gain: gain_b
  states: {}
- name: msink_b
  id: kyttar_sink
  parameters:
    comment: stream B output <- chip x16_out (stream_id "b")
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'True'
    stream_id: '"b"'
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    color2: cyan
    color3: red
    color4: magenta
    comment: A in/out (blue/cyan) vs B in/out (red/magenta)
    grid: 'True'
    label1: A input
    label2: A gained
    label3: B input
    label4: B gained
    name: '"Two multiplexed gain streams (hardware): A & B in/out"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [src_a, '0', msrc_a, '0']
- [msrc_a, '0', gain_blk_a, '0']
- [gain_blk_a, '0', msink_a, '0']
- [src_a, '0', time_sink, '0']
- [msink_a, '0', time_sink, '1']
- [src_b, '0', msrc_b, '0']
- [msrc_b, '0', gain_blk_b, '0']
- [gain_blk_b, '0', msink_b, '0']
- [src_b, '0', time_sink, '2']
- [msink_b, '0', time_sink, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
