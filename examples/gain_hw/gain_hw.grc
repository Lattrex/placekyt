options:
  parameters:
    author: Lattrex
    description: HARDWARE Kyttar Gain demo (CONTINUOUS STREAMING). A live sine from sig_source -> throttle -> kyttar_source (x16_in) -> kyttar_gain -> kyttar_sink (x16_out) -> QT time sink. Unlike the batch gain.grc (for the simulator), this streams real-time samples through the REAL chip. The SAME blocks auto-detect streaming vs batch from the placeKYT server, so you do nothing but toggle Hardware Mode in placeKYT, then Execute here. The plot shows input (top) vs the chip's gained output (bottom), live and continuous.
    generate_options: qt_gui
    id: gain_hw
    output_language: python
    title: Kyttar Gain — HARDWARE streaming (live)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: streaming sample rate into the chip (samples/s)
    value: '4000'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: src
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    comment: CONTINUOUS sine stimulus (real-time streaming, not a bounded burst)
    freq: '4'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    comment: pace the stream to samp_rate so the chip is fed at a real rate
    samples_per_second: samp_rate
    type: float
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: '0'
    comment: stimulus -> chip x16_in. STREAMING when placeKYT is in Hardware Mode (auto-detected from the server); batch on the simulator. Same block.
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: gain
  id: kyttar_gain
  parameters:
    comment: gain block (placed on chip); coefficient reprogrammable at run time
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: gained output <- chip x16_out (continuous stream in Hardware Mode)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: ''
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input (top) vs gained output (bottom), live and continuous
    grid: 'True'
    label1: input
    label2: gained output
    name: '"Kyttar Gain (hardware): input vs output"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [src, '0', throttle, '0']
- [throttle, '0', msrc, '0']
- [msrc, '0', gain, '0']
- [gain, '0', msink, '0']
- [msink, '0', time_sink, '1']
- [throttle, '0', time_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
