options:
  parameters:
    author: Lattrex
    description: 'GRU modulation classifier on ONE placeKYT array. A complex baseband stream enters the chip and a class index (0..3 = SSB / BPSK / 4-FSK / noise) comes back, one word per 32-sample window. The whole chain is on chip: the RMS arm (ComplexToMagSquared -> MovingAverage(32) -> Sqrt -> KeepOneInN(32)), the ZeroCrossingRate(32) arm on the real rail, a FeaturePairJoin rendezvous that emits the ordered (rms, zcr) pair, and a GRUCellBlock (H=4, I=2) with its 4-class readout head and an INTERNAL recurrence. 102 of 120 cells. The shipped stimulus walks all four classes in order and the Class Index scope shows the chip tracking them.'
    generate_options: qt_gui
    id: gru_classifier_grc
    output_language: python
    title: GRU modulation classifier (features + recurrent net on one array)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: the trained model's sample rate (scope axis)
    value: '32000'
  states: {}
- name: window_n
  id: variable
  parameters:
    comment: samples per feature window (config.json window_n)
    value: '32'
  states: {}
- name: n_samples
  id: variable
  parameters:
    comment: shipped stimulus length (complex samples)
    value: stim.n_samples()
  states: {}
- name: n_windows
  id: variable
  parameters:
    comment: class words the chip returns (n_samples / window_n)
    value: stim.n_windows()
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import gru_demo_stim as stim
  states: {}
- name: iq_src
  id: blocks_vector_source_x
  parameters:
    comment: 'the SHIPPED stimulus: four contiguous class segments (ssb, bpsk, fsk4, noise), peak |z| = 0.862 so the Q15 power stage never saturates'
    repeat: 'False'
    type: complex
    vector: stim.iq()
  states: {}
- name: chip_src
  id: kyttar_source
  parameters:
    burst_len: n_samples
    comment: complex baseband -> chip x16_in
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"cls"'
  states: {}
- name: power
  id: kyttar_complex_to_mag_squared
  parameters:
    block_name: '""'
    comment: '|z|^2 (on chip)'
    device_id: '"kyttar_0"'
  states: {}
- name: boxcar
  id: kyttar_moving_average
  parameters:
    block_name: '""'
    comment: boxcar mean of the last 32 power samples = the window mean power
    device_id: '"kyttar_0"'
    length: '32'
    scale: 1.0/32
  states: {}
- name: root
  id: kyttar_sqrt
  parameters:
    block_name: '""'
    comment: sqrt(mean power) = windowed RMS (on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: decim
  id: kyttar_keep_one_in_n
  parameters:
    block_name: '""'
    comment: keep phase 31 — the sample where the boxcar has consumed one whole window
    device_id: '"kyttar_0"'
    n: '32'
  states: {}
- name: zcr
  id: kyttar_zero_crossing_rate
  parameters:
    block_name: '""'
    comment: zero-crossing rate of the real rail over the same 32-sample window
    device_id: '"kyttar_0"'
    window_size: '32'
  states: {}
- name: c2real
  id: blocks_complex_to_real
  parameters:
    comment: the ZCR arm reads the REAL rail
  states: {}
- name: join
  id: kyttar_feature_pair_join
  parameters:
    block_name: '""'
    comment: 'ordered rendezvous: word 0 = RMS (arm a), word 1 = ZCR (arm b) — the order config.json pins and the trained weights expect'
    device_id: '"kyttar_0"'
  states: {}
- name: gru
  id: kyttar_gru_cell
  parameters:
    block_name: '""'
    classes: '4'
    comment: GRU timestep (H=4, I=2) + 4-class readout, recurrence INTERNAL; 51 cells in a wide-flat 10x6 fold. weights_file empty = the bundled trained model.
    device_id: '"kyttar_0"'
    hidden: '4'
    inputs: '2'
    weights_file: '""'
  states: {}
- name: cls_s2f
  id: blocks_short_to_float
  parameters:
    comment: the GRU marker emits SHORT (a RAW class index 0..3, not a Q15 sample — the BinArgmax raw-word convention), and kyttar_sink takes float/complex; this is the type bridge, scale 1 because the word is already the index
    scale: '1'
  states: {}
- name: chip_sink
  id: kyttar_sink
  parameters:
    comment: 'class words <- chip x16_out. This chain''s source is COMPLEX, so the recovered stream comes back as RAW word floats (output_words=auto ties raw to complex_in) — the class index 0..3 arrives as 0.0..3.0 and goes STRAIGHT to the scope. Do NOT put a x32768 rescale in front of it: that is the q15 convention, which applies to real-input chains, and it drives every sample far off the scope''s 0..3 axis.'
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"cls"'
  states: {}
- name: cls_scope
  id: qtgui_time_sink_x
  parameters:
    axislabel: 'True'
    color1: '"blue"'
    comment: 'CLASS INDEX over time. 0 = SSB, 1 = BPSK, 2 = 4-FSK, 3 = noise. The stimulus walks the four in order, so a correct chip draws four ascending plateaus. size is deliberately BELOW the burst (see the README): a QT time sink draws NOTHING until a FULL size buffer arrives, and the GR scheduler strands the tail of a finite stream, so a scope sized >= its burst never paints.'
    grid: 'True'
    label1: class index
    marker1: '0'
    name: '"Class index over time (0=SSB 1=BPSK 2=4FSK 3=noise)"'
    size: n_windows - 16
    srate: samp_rate/window_n
    type: float
    width1: '2'
    ylabel: class
    ymax: '3.5'
    ymin: '-0.5'
  states: {}
- name: truth_src
  id: blocks_vector_source_x
  parameters:
    comment: the stimulus' TRUE class per window, for side-by-side comparison
    repeat: 'True'
    type: float
    vector: stim.truth()
  states: {}
- name: truth_scope
  id: qtgui_time_sink_x
  parameters:
    axislabel: 'True'
    color1: '"green"'
    comment: the TRUE class per window — compare with the chip's verdict above
    grid: 'True'
    label1: true class
    marker1: '0'
    name: '"TRUE class per window (ground truth)"'
    size: n_windows - 16
    srate: samp_rate/window_n
    type: float
    width1: '2'
    ylabel: class
    ymax: '3.5'
    ymin: '-0.5'
  states: {}

connections:
- [iq_src, '0', chip_src, '0']
- [chip_src, '0', power, '0']
- [chip_src, '0', c2real, '0']
- [c2real, '0', zcr, '0']
- [power, '0', boxcar, '0']
- [boxcar, '0', root, '0']
- [root, '0', decim, '0']
- [decim, '0', join, '0']
- [zcr, '0', join, '1']
- [join, '0', gru, '0']
- [gru, '0', cls_s2f, '0']
- [cls_s2f, '0', chip_sink, '0']
- [chip_sink, '0', cls_scope, '0']
- [truth_src, '0', truth_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
