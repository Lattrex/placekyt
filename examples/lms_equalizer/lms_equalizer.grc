options:
  parameters:
    author: Lattrex
    description: 'Adaptive equalizer CONSTELLATION SNAP on the Kyttar array: QPSK symbols smeared by a multipath channel ([1, 0.35, -0.15]) go through the placed decision-directed LMS equalizer; the constellation display shows the channel-distorted cloud (input) versus the equalized output converging onto the four clean decision points (+-0.707 +-0.707j) WITHIN the burst — the adaptation runs live on the chip, per sample. Run as GNURadio Server in placeKYT (port 58950), then Execute here.'
    generate_options: qt_gui
    id: lms_equalizer
    output_language: python
    title: Kyttar LMS equalizer — multipath QPSK constellation snap
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    comment: QPSK symbols per dispatched burst
    value: '600'
  states: {}
- name: iq_stim
  id: variable
  parameters:
    comment: QPSK (seed 7) through the [1, 0.35, -0.15] multipath channel + AWGN (seeded, sigma 0.035/component), scaled /2.4 to keep the burst Q15-safe and the tap-gain need inside the equalizer's envelope
    value: list(((np.convolve(np.array([1+1j,1-1j,-1+1j,-1-1j])[np.random.default_rng(7).integers(0,4,burst_len)],[1.0,0.35,-0.15])[:burst_len]/2.4+0.035*(np.random.default_rng(11).standard_normal(burst_len)+1j*np.random.default_rng(12).standard_normal(burst_len)))).astype(complex))
  states: {}
- name: playback_sps
  id: variable_qtgui_range
  parameters:
    comment: 'convergence playback speed: how many equalized symbols per second reach the display — slide down to WATCH the taps converge, up for full speed'
    label: Convergence playback (symbols/s)
    start: '50'
    step: '50'
    stop: '2000'
    value: '250'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: const_sink
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.35'
    color3: '"magenta"'
    color4: '"green"'
    comment: 'channel-smeared input (blue) vs equalized output COLORED BY TIME: red = cold start, magenta = adapting, green = converged'
    grid: 'True'
    label1: channel-distorted input
    label2: 'equalized: first 100 (cold start)'
    label3: 'equalized: 100-250 (adapting)'
    label4: 'equalized: 250+ (converged)'
    name: '"LMS constellation snap: color = when (red early, green converged)"'
    nconnections: '4'
    size: '600'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: eq
  id: kyttar_lms_equalizer
  parameters:
    block_name: '""'
    comment: decision-directed complex LMS (5 taps, mu 0.03) — placed on chip
    device_id: '"kyttar_0"'
    num_taps: '5'
    sps: '1'
    step_size: '0.03'
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iq2c
  id: epy_block
  parameters:
    _source_code: |
      """Interleaved I,Q floats -> complex pairs (2:1).

      The kyttar sink emits a complex chain's recovered stream as INTERLEAVED
      I,Q float32 (its output port is always float); this embedded block
      reassembles gr_complex for the constellation display. An embedded block
      (not blocks.float_to_complex) on purpose: stock converter ids are chip-side
      splice markers to the placeKYT importer, and this display glue must stay
      host-side."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self):
              gr.decim_block.__init__(self, name='IQ Pairs to Complex',
                                      in_sig=[np.float32],
                                      out_sig=[np.complex64], decim=2)

          def work(self, input_items, output_items):
              n = len(output_items[0])
              x = input_items[0][:2 * n]
              output_items[0][:] = x[0::2] + 1j * x[1::2]
              return n
    comment: interleaved I,Q floats -> gr_complex (host-side display glue)
  states: {}
- name: phases
  id: epy_block
  parameters:
    _source_code: |
      """Convergence phase splitter — encode TIME as COLOR.

      The QT constellation sink repaints only when its whole size-buffer is
      full, so a single-stream display can never show WHERE the new points
      are. Instead, split each 600-symbol burst into three phase streams
      (early / adapting / converged) drawn as separately-colored overlays:
      one glance shows the early scatter (red), the pull-in (magenta) and
      the converged corners (green). Off-phase samples are parked outside
      the visible window (the sync sink needs equal-rate inputs).
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, burst=600, early=100, mid=250):
              gr.sync_block.__init__(self, name='Convergence Phases',
                                     in_sig=[np.complex64],
                                     out_sig=[np.complex64] * 3)
              self.burst = int(burst)
              self.early = int(early)
              self.mid = int(mid)
              self.k = 0
              self.park = 10 + 10j     # far outside the +-1.2 window

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              idx = (self.k + np.arange(n)) % self.burst
              bands = ((0, self.early), (self.early, self.mid),
                       (self.mid, self.burst))
              for p, (lo, hi) in enumerate(bands):
                  out = output_items[p]
                  out[:n] = self.park
                  m = (idx >= lo) & (idx < hi)
                  out[:n][m] = x[m]
              self.k = (self.k + n) % self.burst
              return n
    burst: burst_len
    comment: splits each burst into early/adapting/converged streams so the constellation shows WHEN each point happened
    early: '100'
    mid: '250'
  states: {}
- name: errcurve
  id: epy_block
  parameters:
    _source_code: |
      """Convergence learning curve — |y - nearest decision point|, smoothed.

      The quantitative "it is getting better": per equalized symbol, the
      distance to the nearest QPSK decision point (+-0.7071 +-0.7071j),
      lightly EMA-smoothed so the decay reads as a curve. Restarts high at
      every burst boundary (the chip cold-starts per batch) and decays as
      the on-chip taps adapt.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Distance to Decision',
                                     in_sig=[np.complex64],
                                     out_sig=[np.float32])
              self.d = 0.70710678
              self.ema = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              dec = (np.sign(x.real) * self.d
                     + 1j * np.sign(x.imag) * self.d)
              err = np.abs(x - dec).astype(np.float32)
              out = output_items[0]
              a = 0.15
              e = self.ema
              for i in range(len(err)):
                  e = (1.0 - a) * e + a * float(err[i])
                  out[i] = e
              self.ema = e
              return len(err)
    comment: the learning curve — smoothed distance to the nearest decision point, per symbol
  states: {}
- name: err_sink
  id: qtgui_time_sink_x
  parameters:
    color1: dark red
    comment: the learning curve — restarts at each burst's cold start, decays as the on-chip taps adapt
    grid: 'True'
    label1: distance to decision (smoothed)
    name: '"Convergence: error vs symbol (one burst = one decay)"'
    size: '600'
    srate: playback_sps
    type: float
    width1: '2'
    ylabel: '|error|'
    ymax: '0.8'
    ymin: '0.0'
  states: {}
- name: ksink
  id: kyttar_sink
  parameters:
    comment: 'equalized I/Q <- x16_out (interleaved I,Q floats). CONTINUOUS mode: the repeat-burst source drives a fresh burst each pass (the chip cold-starts per batch), so the stream never ends and server_repeat stays off'
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: complex
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '""'
  states: {}
- name: ksrc
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: I/Q burst -> chip x16_in (per-sample drive — the LMS adapts sample by sample)
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"q15"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'yes'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '""'
  states: {}
- name: playback
  id: blocks_throttle
  parameters:
    comment: paces the equalized stream to the display so the snap DRAWS itself (host-side display pacing only — the chip already ran at full speed)
    samples_per_second: playback_sps
    type: complex
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: channel-distorted QPSK burst (repeat for a stable live plot)
    repeat: 'True'
    type: complex
    vector: iq_stim
  states: {}

connections:
- [eq, '0', ksink, '0']
- [errcurve, '0', err_sink, '0']
- [iq2c, '0', playback, '0']
- [ksink, '0', iq2c, '0']
- [ksrc, '0', eq, '0']
- [phases, '0', const_sink, '1']
- [phases, '1', const_sink, '2']
- [phases, '2', const_sink, '3']
- [playback, '0', errcurve, '0']
- [playback, '0', phases, '0']
- [src, '0', const_sink, '0']
- [src, '0', ksrc, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
