options:
  parameters:
    author: Lattrex
    description: 'A FULL PSK31 TRANSCEIVER on one placeKYT chip: TX (chars -> SRAM-backed Varicode encoder -> differential BPSK -> hold x8 -> raised-cosine envelope) and RX (symbols -> BPSK slicer -> diff decoder -> SRAM-backed Varicode DECODER -> chars) duplexed by stream tags, with BOTH Varicode tables SHARING the single SRAM panel (the encoder''s table at addr_base 1024, clear of the decoder''s 1..955 reverse map; every panel read carries its own push-read descriptors). PER-SAMPLE PACED (the panel contract; the server enforces it).'
    generate_options: qt_gui
    id: psk31_transceiver
    output_language: python
    title: PSK31 full transceiver (duplex, shared SRAM panel)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: scope display rate (8 sps x 31.25 Bd)
    value: '250'
  states: {}
- name: imports
  id: import
  parameters:
    imports: import math
  states: {}
- name: sps
  id: variable
  parameters:
    comment: TX samples per symbol
    value: '8'
  states: {}
- name: msg
  id: variable
  parameters:
    comment: TX message chars
    value: '[ord(c) for c in ''CQ CQ DE KYTTAR'']'
  states: {}
- name: burst_len
  id: variable
  parameters:
    value: len(msg)
  states: {}
- name: rx_sig
  id: variable
  parameters:
    comment: differentially-encoded Varicode symbols for 'R 599 73' at symbol rate, mapped to +/-0.9 soft symbols -- exactly what a coherent PSK31 demodulator hands the slicer. Replace with a live demod feed.
    value: '[0.9 if int(v) else -0.9 for v in __import__(''itertools'').accumulate([int(c) for c in ''001010111100100101011011001101101110011011011100100110101101001111111100''], lambda a,x:(a+x)%2)]'
  states: {}
- name: rx_burst_len
  id: variable
  parameters:
    value: len(rx_sig)
  states: {}
- name: msg_src
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: msg
  states: {}
- name: b2f_in
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: to_raw
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: f2b
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: varicode
  id: kyttar_varicode_encoder
  parameters:
    device_id: '"kyttar_0"'
    panel_hop: '1'
    emit_hop: '1'
    emit_dest: '25'
    emit_entry: '1'
    read_wr_desc: '0'
    read_jp_desc: '0'
    addr_base: '1024'
  states: {}
- name: diff
  id: kyttar_diff_encoder
  parameters:
    device_id: '"kyttar_0"'
    modulus: '2'
    coding: '"DIFF_DIFFERENTIAL"'
  states: {}
- name: b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: mapper
  id: kyttar_psk_symbol_mapper
  parameters:
    device_id: '"kyttar_0"'
    modulation: '"bpsk"'
    symbol_table: '[]'
    dimension: '1'
    bpsk_bit0_positive: 'True'
  states: {}
- name: c2r
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: repeat
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: envelope
  id: kyttar_raised_cosine_envelope
  parameters:
    device_id: '"kyttar_0"'
    samples_per_symbol: sps
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"TX baseband (PSK31 shaped)"'
    size: '256'
    srate: samp_rate
    type: float
    ylabel: level
  states: {}
- name: rx_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_vec
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: rx_sig
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: rx_burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: slicer
  id: kyttar_bpsk_slicer
  parameters:
    device_id: '"kyttar_0"'
    out_mode: '"bit"'
  states: {}
- name: ddec
  id: kyttar_diff_decoder
  parameters:
    device_id: '"kyttar_0"'
    modulus: '2'
    coding: '0'
  states: {}
- name: vdec
  id: kyttar_varicode_decoder
  parameters:
    device_id: '"kyttar_0"'
    panel_hop: '1'
    read_addr_hop: '1'
    char_dest: '25'
    emit_entry: '2'
    emit_hop: '1'
    out_dest: '25'
    read_dest: '5'
    read_entry: '1'
    read_wr_desc: '0'
    read_jp_desc: '0'
    emit_jump_entry: None
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: rx_scope
  id: qtgui_time_sink_x
  parameters:
    name: '"RX decoded chars (ASCII codes)"'
    size: '8'
    srate: samp_rate
    type: float
    ylabel: level
    ymax: '128'
    ymin: '0'
  states: {}
- name: rx_chars
  id: blocks_multiply_const_vxx
  parameters:
    comment: kyttar.sink emits the chip stream as q15/32768 floats; restore the raw word value for display
    const: '32768.0'
    type: float
  states: {}

connections:
- [msg_src, '0', b2f_in, '0']
- [b2f_in, '0', to_raw, '0']
- [to_raw, '0', tx_src, '0']
- [tx_src, '0', f2b, '0']
- [f2b, '0', varicode, '0']
- [varicode, '0', diff, '0']
- [diff, '0', b2f, '0']
- [b2f, '0', mapper, '0']
- [mapper, '0', c2r, '0']
- [c2r, '0', repeat, '0']
- [repeat, '0', envelope, '0']
- [envelope, '0', tx_sink, '0']
- [tx_sink, '0', tx_scope, '0']
- [rx_vec, '0', rx_src, '0']
- [rx_src, '0', slicer, '0']
- [slicer, '0', ddec, '0']
- [ddec, '0', vdec, '0']
- [vdec, '0', rx_b2f, '0']
- [rx_b2f, '0', rx_sink, '0']
- [rx_sink, '0', rx_chars, '0']
- [rx_chars, '0', rx_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
