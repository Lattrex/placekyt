options:
  parameters:
    author: Lattrex
    description: 'Coherent 16-QAM receiver on the Kyttar array: a decision-directed complex Costas loop recovers the carrier, then a 16-QAM hard-decision slicer emits the 4-bit symbol index. Built from the REAL DSP blocks (QAM16ComplexCostasLoop -> QAM16Slicer) so it IMPORTS into placeKYT. NOTE: this is a dense hand-placed design — OPEN qam16_modem.kyt to host the chip (importing this .grc auto-places the blocks away from the input port and the DD loop won''t lock). Simulation -> Run as GNURadio Server, set server_port to the printed port, then Execute here.'
    generate_options: qt_gui
    id: qam16_modem
    output_language: python
    title: Coherent 16-QAM RX (DD Costas + slicer) — input vs recovered symbols
  states: {}

blocks:
- name: n_syms
  id: variable
  parameters:
    comment: 16-QAM symbols in the burst
    value: '400'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: bit_sink
  id: qtgui_time_sink_x
  parameters:
    comment: recovered bits (chip out) — MF + Costas + Gardner RX
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: recovered bit
    name: '"Recovered bits (chip x16_out)"'
    size: '128'
    srate: '1'
    type: float
    ylabel: bit
    ymax: '1.3'
    ymin: '-0.3'
  states: {}
- name: costas
  id: kyttar_qam16_costas_loop
  parameters:
    comment: 16-QAM decision-directed carrier recovery (on chip)
    device_id: '"kyttar_0"'
    alpha_q15: '2048'
    beta_q15: '32'
  states: {}
- name: import_stim
  id: import
  parameters:
    comment: RRC BPSK burst generator (carrier + timing offset)
    imports: |
      import numpy as np, random, math
      _N=1.0/math.sqrt(10.0)
      _L=[(1,-1),(-1,-1),(3,-3),(-3,-3),(-3,-1),(3,-1),(-1,-3),(1,-3),(-3,3),(3,3),(-1,1),(1,1),(1,3),(-1,3),(3,1),(-3,1)]
      _P=[complex(i*_N,q*_N) for (i,q) in _L]
      def qam16_burst(n, foff=0.002, seed=5):
          random.seed(seed); s=[random.randint(0,15) for _ in range(n)]
          return [ _P[sm]*complex(math.cos(2*math.pi*foff*k),math.sin(2*math.pi*foff*k)) for k,sm in enumerate(s) ]
  states: {}
- name: input_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input RRC BPSK waveform (in-phase, before the chip)
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: input I
    name: '"Input waveform (RRC BPSK, in-phase)"'
    size: '256'
    srate: '1'
    type: complex
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: recovered bits <- placeKYT chip x16_out (batch)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '""'
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: n_syms
    comment: I/Q burst -> placeKYT chip x16_in (batch); fans to MF xi/xq
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '""'
  states: {}
- name: slicer
  id: kyttar_qam16_slicer
  parameters:
    comment: 16-QAM hard-decision slicer (on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: RRC BPSK burst (carrier + timing offset) into the chip — REPEAT so the flowgraph never reaches EOF (which would tear down the graph before the QT time sink ever paints); the Kyttar Source dispatches the batch ONCE then passes through, and the Sink re-emits the recovered bits for a stable live plot.
    repeat: 'True'
    type: complex
    vector: qam16_burst(n_syms)
  states: {}

connections:
- [src, '0', msrc, '0']
- [src, '0', input_sink, '0']
- [msrc, '0', costas, '0']
- [costas, '0', slicer, '0']
- [slicer, '0', msink, '0']
- [msink, '0', bit_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
