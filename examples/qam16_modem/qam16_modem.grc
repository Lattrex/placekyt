options:
  parameters:
    author: Lattrex
    description: 'Full-duplex 16-QAM modem authored in GNU Radio (GRC-first workflow). The TX chain (16-QAM symbol mapper -> complex upsampler -> complex RRC pulse shaper -> I/Q upconvert) and the coherent RX chain (complex RRC matched filter -> complex gain -> Mueller & Muller decision-directed symbol-timing recovery -> QAM16 decision-directed Costas -> QAM16 hard-decision slicer) live on ONE placeKYT array, sharing ONE input port (x16_in) and ONE output port (x16_out): both TX and RX source blocks map to x16_in and both sink blocks map to x16_out (the shared-port duplex, exactly like the QPSK modem). Built from the REAL DSP blocks so it IMPORTS into placeKYT (File -> Import GNURadio Flowgraph): every block gets placed + the logical nets are recovered, and the RX chain recovers the 4-bit 16-QAM symbols at BER 0 through simKYT. On-chip CO-PLACEMENT of the full duplex is up to the user: the M&M timing block is a large feedback block and the auto-router congests from a fresh import, so hand-place the chip (open a .kyt) rather than auto-P&R the whole duplex. NO carrier frequency offset: the hosted TX and RX share one clock, so the decision-directed M&M TED sees foff = 0 by construction.'
    generate_options: qt_gui
    id: qam16_modem
    output_language: python
    run_options: run
    title: Full-duplex 16-QAM modem (TX + coherent RX on one array)
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    comment: TX carrier frequency
    value: '4000'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: gain-stage the MF output to the 0.949 outer level
    value: '2.4'
  states: {}
- name: n_bits
  id: variable
  parameters:
    comment: TX bits in the burst (4/symbol) -> 1600 bits = 400 symbols
    value: '1600'
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: RX 16-QAM symbols in the burst
    value: '400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TX passband sample rate
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: TX samples per symbol
    value: '2'
  states: {}
- name: cgain
  id: kyttar_complex_gain
  parameters:
    comment: gain-stage the MF output to the 0.949 outer level -- placed on chip
    device_id: '"kyttar_0"'
    gain: '2.4'
  states: {}
- name: costas
  id: kyttar_qam16_costas_loop
  parameters:
    alpha_q15: '1024'
    beta_q15: '32'
    comment: 16-QAM decision-directed carrier recovery -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import qam16_demo_stim as stim
  states: {}
- name: mapper
  id: kyttar_qam16_symbol_mapper
  parameters:
    comment: 16-QAM symbol mapper (4 bits -> constellation point) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC matched filter front end -- placed on chip
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: mm
  id: kyttar_mm_timing_recovery
  parameters:
    comment: M&M decision-directed symbol-timing recovery -- placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.02'
    sps: sps
  states: {}
- name: rrc
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC pulse shaper (matched-filter block reused) -- placed on chip
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: RX RRC 16-QAM I/Q burst (no carrier offset; same-chip TX); finite, no repeat
    repeat: 'False'
    type: complex
    vector: stim.burst(n_syms)
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered symbols -> placeKYT chip x16_out (shared duplex port, stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: stim.burst_len(n_syms)
    comment: RX I/Q burst -> placeKYT chip x16_in (shared duplex port, stream 'rx')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: rx_syms
  id: qtgui_time_sink_x
  parameters:
    comment: recovered 4-bit 16-QAM symbols from the chip x16_out (stream 'rx')
    grid: 'True'
    label1: recovered symbol
    name: '"Recovered 16-QAM symbols"'
    size: stim.rx_syms_points(n_syms)
    srate: '1'
    type: float
    ylabel: symbol
    ymax: '15'
    ymin: '0'
  states: {}
- name: slicer
  id: kyttar_qam16_slicer
  parameters:
    comment: 16-QAM hard-decision slicer (recovered 4-bit symbol) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bit stimulus (one finite burst -> EOF dispatches it; no repeat)
    repeat: 'False'
    type: float
    vector: stim.tx_bits(n_bits)
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    comment: TX passband (real) — recovered from the chip x16_out (stream 'tx')
    name: '"TX passband (real)"'
    size: stim.tx_pb_points(n_bits)
    srate: samp_rate
    type: float
    ylabel: amplitude
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: TX passband -> placeKYT chip x16_out (shared duplex port, stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_bits
    comment: TX bits -> placeKYT chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: up
  id: kyttar_complex_upsampler
  parameters:
    comment: Complex (I/Q) zero-stuff upsampler (sps) -- placed on chip
    device_id: '"kyttar_0"'
    sps: sps
  states: {}
- name: upc
  id: kyttar_iq_upconvert
  parameters:
    comment: I/Q upconvert to real passband -- placed on chip
    device_id: '"kyttar_0"'
    frequency: '4000'
    sample_rate: '32000'
  states: {}

connections:
- [cgain, '0', mm, '0']
- [costas, '0', slicer, '0']
- [mapper, '0', up, '0']
- [mf, '0', cgain, '0']
- [mm, '0', costas, '0']
- [rrc, '0', upc, '0']
- [rx_iq, '0', rx_src, '0']
- [rx_sink, '0', rx_syms, '0']
- [rx_src, '0', mf, '0']
- [slicer, '0', rx_sink, '0']
- [tx_bits, '0', tx_src, '0']
- [tx_sink, '0', tx_passband, '0']
- [tx_src, '0', mapper, '0']
- [up, '0', rrc, '0']
- [upc, '0', tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
