options:
  parameters:
    author: Lattrex
    description: 'PRODUCTION coherent QPSK RX demo with the RRC matched-filter front end (GRC-first workflow). Built from the REAL DSP blocks so it IMPORTS into placeKYT: ComplexRRCMatchedFilter -> ComplexCostasLoop(order=4) -> GardnerTimingRecovery(complex) -> QPSKSlicer get placed + bus-routed; source/sink -> chip ports. The SAME flowgraph RUNS linked to the placeKYT-hosted chip: Simulation -> Run as GNURadio Server in placeKYT, set server_port below to the printed port, then Execute here. kyttar_source batches the whole I/Q burst through the hosted chip in one RPC. The QT time sinks show the INPUT waveform (top) versus the RECOVERED 2-bit QPSK symbols (bottom) — the input-vs-output view.'
    generate_options: qt_gui
    id: qpsk_modem
    output_language: python
    title: Coherent QPSK RX (RRC matched filter) — input vs recovered symbols
  states: {}

blocks:
- name: n_syms
  id: variable
  parameters:
    comment: QPSK symbols in the burst
    value: '160'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {}
- name: import_stim
  id: import
  parameters:
    comment: RRC QPSK burst generator (carrier + timing offset)
    imports: from gnuradio.kyttar import qpsk_demo_stim as stim
  states: {}
- name: src
  id: blocks_vector_source_x
  parameters:
    comment: RRC QPSK burst (carrier + timing offset) into the chip — REPEAT so the flowgraph never reaches EOF; the Kyttar Source dispatches the batch ONCE then passes through, and the Sink re-emits the recovered symbols for a stable live plot.
    repeat: 'True'
    type: complex
    vector: stim.burst(n_syms)
  states: {}
- name: c2f
  id: blocks_complex_to_float
  parameters:
    comment: split I (re) for the input-waveform view
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: stim.burst_len(n_syms)
    comment: I/Q burst -> placeKYT chip x16_in (batch); fans to MF xi/xq
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: RRC matched filter front end (placed on chip)
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: Order-4 (QPSK) Costas carrier recovery (placed on chip)
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
    order: '4'
  states: {}
- name: gardner
  id: kyttar_gardner_ted
  parameters:
    comment: Complex (I/Q) Gardner timing recovery (placed on chip)
    complex: 'True'
    device_id: '"kyttar_0"'
    ki: '1'
    kp: '3'
  states: {}
- name: slicer
  id: kyttar_qpsk_slicer
  parameters:
    comment: QPSK hard-decision slicer (placed on chip)
    device_id: '"kyttar_0"'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: recovered symbols <- placeKYT chip x16_out (batch)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
  states: {}
- name: input_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input RRC QPSK waveform (in-phase, before the chip)
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: input I
    name: '"Input waveform (RRC QPSK, in-phase)"'
    size: '256'
    srate: '1'
    type: float
    ylabel: amplitude
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: sym_sink
  id: qtgui_time_sink_x
  parameters:
    comment: recovered QPSK symbols (chip out) — MF + Costas4 + Gardner + slicer
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: recovered symbol
    name: '"Recovered QPSK symbols (chip x16_out)"'
    size: '128'
    srate: '1'
    type: float
    ylabel: symbol
    ymax: '3.3'
    ymin: '-0.3'
  states: {}

connections:
- [c2f, '0', input_sink, '0']
- [costas, '0', gardner, '0']
- [costas, '1', gardner, '1']
- [gardner, '0', slicer, '0']
- [gardner, '1', slicer, '1']
- [mf, '0', costas, '0']
- [mf, '1', costas, '1']
- [msink, '0', sym_sink, '0']
- [msrc, '0', mf, '0']
- [msrc, '0', mf, '1']
- [slicer, '0', msink, '0']
- [src, '0', c2f, '0']
- [src, '0', msrc, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
