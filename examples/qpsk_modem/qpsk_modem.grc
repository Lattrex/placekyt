options:
  parameters:
    author: Lattrex
    description: 'Full-duplex QPSK modem authored in GNU Radio (GRC-first workflow). The TX chain (QPSK symbol mapper -> complex upsampler -> complex RRC pulse shaper -> I/Q upconvert) and the coherent RX chain (complex RRC matched filter -> order-4 complex Costas loop -> M&M timing recovery -> QPSK slicer) live on ONE placeKYT array, sharing ONE input port (x16_in) and ONE output port (x16_out): both TX and RX source blocks map to x16_in and both sink blocks map to x16_out (the shared-port duplex). Built from the REAL DSP blocks so it IMPORTS into placeKYT (File -> Import GNURadio Flowgraph): all 8 blocks get placed + the logical nets are recovered, and the RX chain recovers the 2-bit QPSK symbols at BER 0 on the built bitstream through simKYT (placekyt/tests/test_qpsk_modem_ber.py).'
    generate_options: qt_gui
    id: qpsk_modem
    output_language: python
    run_options: run
    title: Full-duplex QPSK modem (TX + coherent RX on one array)
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    comment: TX carrier frequency
    value: '4000'
  states: {}
- name: n_bits
  id: variable
  parameters:
    comment: TX bits in the burst (2/symbol)
    value: '64'
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: RX symbols in the burst
    value: '160'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TX passband sample rate
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: TX samples per symbol
    value: '2'
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    comment: TX passband (real) — recovered from the chip x16_out (stream 'tx')
    name: '"TX passband (real)"'
    size: stim.tx_pb_points(n_bits)
    srate: samp_rate
    type: float
    ylabel: amplitude
  states: {}
- name: rx_syms
  id: qtgui_time_sink_x
  parameters:
    comment: recovered 2-bit QPSK symbols from the chip x16_out (stream 'rx')
    name: '"Recovered symbols"'
    size: stim.rx_syms_points(n_syms)
    srate: samp_rate
    type: float
    ylabel: symbol
    ymax: '3'
    ymin: '0'
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: Order-4 (QPSK) complex Costas carrier recovery -- placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
    order: '4'
  states: {}
- name: mmtiming
  id: kyttar_mm_timing_recovery
  parameters:
    comment: M&M decision-directed timing recovery (I/Q) -- placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.02'
    sps: '2'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import qpsk_demo_stim as stim
  states: {}
- name: mapper
  id: kyttar_psk_symbol_mapper
  parameters:
    comment: PSK symbol mapper (QPSK) -- placed on chip
    device_id: '"kyttar_0"'
    modulation: '"qpsk"'
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC matched filter front end -- placed on chip
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: rrc
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC pulse shaper (matched-filter block reused) -- placed on chip
    decimation: '1'
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: RX RRC-QPSK I/Q burst (carrier+timing offset); finite, no repeat
    repeat: 'False'
    type: complex
    vector: stim.burst(n_syms)
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered symbols -> placeKYT chip x16_out (shared duplex port, stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: stim.burst_len(n_syms)
    comment: RX I/Q burst -> placeKYT chip x16_in (shared duplex port, stream 'rx')
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: slicer
  id: kyttar_qpsk_slicer
  parameters:
    comment: QPSK slicer (recovered 2-bit symbols) -- placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bit stimulus (one finite burst -> EOF dispatches it; no repeat)
    repeat: 'False'
    type: float
    vector: stim.tx_bits(n_bits)
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: TX passband -> placeKYT chip x16_out (shared duplex port, stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_bits
    comment: TX bits -> placeKYT chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
  states: {}
- name: up
  id: kyttar_complex_upsampler
  parameters:
    comment: Complex (I/Q) zero-stuff upsampler (sps) -- placed on chip
    device_id: '"kyttar_0"'
    sps: sps
  states: {}
- name: upc
  id: kyttar_iq_upconvert
  parameters:
    comment: I/Q upconvert to real passband -- placed on chip
    device_id: '"kyttar_0"'
    frequency: '4000'
    sample_rate: '32000'
  states: {}

connections:
- [costas, '0', mmtiming, '0']
- [mmtiming, '0', slicer, '0']
- [mapper, '0', up, '0']
- [mf, '0', costas, '0']
- [rrc, '0', upc, '0']
- [rx_iq, '0', rx_src, '0']
- [rx_sink, '0', rx_syms, '0']
- [rx_src, '0', mf, '0']
- [slicer, '0', rx_sink, '0']
- [tx_bits, '0', tx_src, '0']
- [tx_sink, '0', tx_passband, '0']
- [tx_src, '0', mapper, '0']
- [up, '0', rrc, '0']
- [upc, '0', tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
