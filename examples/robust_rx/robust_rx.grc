options:
  parameters:
    author: Lattrex
    description: 'ROBUST RX — coarse frequency recovery on one placeKYT array. One raised-cosine BPSK burst carries a LARGE carrier offset (0.18 cycles/sample, far beyond a Costas loop''s pull-in) into TWO placed receiver chains: ''rx'' = FLL band-edge (coarse frequency recovery) -> Costas(order 2) -> BPSK slicer, which LOCKS and recovers the bits; ''ctl'' = the same Costas -> slicer WITHOUT the FLL (the classic coherent chain''s carrier-recovery core), which cannot pull the offset — its recovered bits are garbage. The on-screen story: at real-world frequency offsets the old chain dies, the FLL-fronted one locks.'
    generate_options: qt_gui
    id: robust_rx
    output_language: python
    title: Robust RX — FLL coarse frequency recovery vs Costas-only
  states: {}

blocks:
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import robust_demo_stim as stim
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display sample rate (scope axis only)
    value: '32000'
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: BPSK symbols in the burst
    value: '600'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: complex samples per burst (2 sps)
    value: stim.n_rx(n_syms)
  states: {}
- name: rx_iq
  id: blocks_vector_source_x
  parameters:
    comment: RC-shaped BPSK burst, carrier offset foff = 0.18 cyc/sample (far beyond Costas pull-in); finite, no repeat
    repeat: 'False'
    type: complex
    vector: stim.rx_burst(n_syms)
  states: {}
- name: input_scope
  id: qtgui_time_sink_x
  parameters:
    comment: the offset burst as the antenna sees it (I and Q spinning at 0.18 cyc/sample)
    name: '"RF burst (foff = 0.18 cyc/sample)"'
    size: burst_len - 16
    srate: samp_rate
    type: complex
    ylabel: level
  states: {}
- name: fll_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: 'the offset burst -> chip x16_in (stream ''rx'': FLL -> Costas -> slicer)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
  states: {}
- name: fll
  id: kyttar_fll_band_edge
  parameters:
    bandwidth: '0.1'
    comment: coarse frequency recovery (band-edge FLL) — placed on chip
    device_id: '"kyttar_0"'
    filter_size: '17'
    rolloff: '0.35'
    samps_per_sym: '2.0'
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: fine carrier recovery (BPSK Costas) — placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
    order: '2'
  states: {}
- name: slicer
  id: kyttar_bpsk_slicer
  parameters:
    comment: hard bit decisions — placed on chip
    device_id: '"kyttar_0"'
    out_mode: '"bit"'
  states: {}
- name: slicer_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bits <- chip x16_out (stream 'rx'); a complex-input chain emits RAW word floats (the receiver convention), so the 0/1 bits plot directly
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"rx"'
  states: {}
- name: fll_bits_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'the FLL-fronted chain LOCKS: clean hard bits after the ~150-symbol acquisition'
    name: '"Recovered bits — FLL + Costas (locks)"'
    size: stim.n_rx_bits(n_syms)
    srate: samp_rate
    type: float
    ylabel: bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: ctl_src
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: 'the SAME offset burst -> chip x16_in (stream ''ctl'': Costas -> slicer, NO FLL — the negative control)'
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'no'
    port_name: '"x16_in"'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"ctl"'
  states: {}
- name: ctl_costas
  id: kyttar_costas_loop
  parameters:
    comment: 'the OLD chain: Costas alone (pull-in ~0.12 cyc/sample — 0.18 is out of reach)'
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
    order: '2'
  states: {}
- name: ctl_slicer
  id: kyttar_bpsk_slicer
  parameters:
    device_id: '"kyttar_0"'
    out_mode: '"bit"'
  states: {}
- name: ctl_b2f
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: ctl_sink
  id: kyttar_sink
  parameters:
    comment: garbage bits <- chip x16_out (stream 'ctl'); raw word floats, 0/1 plots directly
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"ctl"'
  states: {}
- name: ctl_bits_scope
  id: qtgui_time_sink_x
  parameters:
    color1: red
    comment: 'the Costas-only chain NEVER locks at this offset: the bits churn (BER ~0.2)'
    name: '"Recovered bits — Costas only (fails)"'
    size: stim.n_rx_bits(n_syms)
    srate: samp_rate
    type: float
    ylabel: bit
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [rx_iq, '0', input_scope, '0']
- [rx_iq, '0', fll_src, '0']
- [rx_iq, '0', ctl_src, '0']
- [fll_src, '0', fll, '0']
- [fll, '0', costas, '0']
- [costas, '0', slicer, '0']
- [slicer, '0', slicer_b2f, '0']
- [slicer_b2f, '0', rx_sink, '0']
- [rx_sink, '0', fll_bits_scope, '0']
- [ctl_src, '0', ctl_costas, '0']
- [ctl_costas, '0', ctl_slicer, '0']
- [ctl_slicer, '0', ctl_b2f, '0']
- [ctl_b2f, '0', ctl_sink, '0']
- [ctl_sink, '0', ctl_bits_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
