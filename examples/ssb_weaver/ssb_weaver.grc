options:
  parameters:
    author: Kyttar
    description: 'FULL on-chip SSB Weaver TRANSCEIVER built from REAL blocks (4 real multipliers + a subtract per half, exactly the Weaver diagram). audio -> NCO(fa) mixers -> 2x LowPass -> NCO(fc) mixers -> Subtract [SSB] -> NCO(fc) mixers -> 2x LowPass -> NCO(fa) mixers -> Subtract -> Gain -> recovered audio. Imports into placeKYT: two clean real filaments, no complex-block fan-in. Run as GNURadio Server in placeKYT + Execute here to stream audio.'
    generate_options: qt_gui
    id: ssb_weaver_transceiver
    output_language: python
    title: SSB Weaver transceiver (on-chip, real blocks) — audio in vs recovered
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000.0'
  states: {}
- name: n_samp
  id: variable
  parameters:
    comment: audio burst length
    value: '2048'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT GNURadio-server port
    value: '58950'
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: tone2
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: '1800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio
  id: blocks_add_xx
  parameters:
    comment: input audio (2 tones)
    type: float
  states: {}
- name: thr
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: audio -> chip x16_in (batch)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: tx_lo_a
  id: kyttar_nco
  parameters:
    amplitude: '0.9'
    device_id: '"kyttar_0"'
    frequency: '1500.0'
    offset: '0'
    phase: '0'
    sample_rate: '32000.0'
    waveform: cos
  states: {}
- name: tx_mi
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: tx_mq
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: tx_lpi
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    decimation: '1'
    device_id: '"kyttar_0"'
    gain: '1'
    interpolation: '1'
    samp_rate: '32000.0'
    transition_width: '2500.0'
    window: hamming
  states: {}
- name: tx_lpq
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    decimation: '1'
    device_id: '"kyttar_0"'
    gain: '1'
    interpolation: '1'
    samp_rate: '32000.0'
    transition_width: '2500.0'
    window: hamming
  states: {}
- name: tx_lo_c
  id: kyttar_nco
  parameters:
    amplitude: '0.9'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    offset: '0'
    phase: '0'
    sample_rate: '32000.0'
    waveform: cos
  states: {}
- name: tx_ui
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: tx_uq
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: tx_ssb
  id: kyttar_subtract
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_lo_c
  id: kyttar_nco
  parameters:
    amplitude: '0.9'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    offset: '0'
    phase: '0'
    sample_rate: '32000.0'
    waveform: cos
  states: {}
- name: rx_mi
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_mq
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_lpi
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    decimation: '1'
    device_id: '"kyttar_0"'
    gain: '1'
    interpolation: '1'
    samp_rate: '32000.0'
    transition_width: '2500.0'
    window: hamming
  states: {}
- name: rx_lpq
  id: kyttar_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    decimation: '1'
    device_id: '"kyttar_0"'
    gain: '1'
    interpolation: '1'
    samp_rate: '32000.0'
    transition_width: '2500.0'
    window: hamming
  states: {}
- name: rx_lo_a
  id: kyttar_nco
  parameters:
    amplitude: '0.9'
    device_id: '"kyttar_0"'
    frequency: '1500.0'
    offset: '0'
    phase: '0'
    sample_rate: '32000.0'
    waveform: cos
  states: {}
- name: rx_ui
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_uq
  id: kyttar_multiply
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: rx_aud
  id: kyttar_subtract
  parameters:
    device_id: '"kyttar_0"'
    num_inputs: '2'
  states: {}
- name: g4
  id: kyttar_gain
  parameters:
    comment: Weaver 1/4 -> x4
    device_id: '"kyttar_0"'
    gain: '4'
  states: {}
- name: msink
  id: kyttar_sink
  parameters:
    comment: recovered audio <- x16_out
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_out"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: ''
  states: {}
- name: in_sink
  id: qtgui_time_sink_x
  parameters:
    bw: samp_rate
    grid: 'True'
    label1: input audio
    name: Input audio
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
    grid_color1: blue
  states: {}
- name: out_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    grid: 'True'
    label1: recovered audio
    name: Recovered audio (chip out)
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
    grid_color1: green
  states: {}

connections:
- [tone, '0', audio, '0']
- [tone2, '0', audio, '1']
- [audio, '0', thr, '0']
- [thr, '0', msrc, '0']
- [thr, '0', in_sink, '0']
- [msrc, '0', tx_mi, '0']
- [msrc, '0', tx_mq, '0']
- [tx_lo_a, '0', tx_mi, '1']
- [tx_lo_a, '1', tx_mq, '1']
- [tx_mi, '0', tx_lpi, '0']
- [tx_mq, '0', tx_lpq, '0']
- [tx_lpi, '0', tx_ui, '0']
- [tx_lo_c, '0', tx_ui, '1']
- [tx_lpq, '0', tx_uq, '0']
- [tx_lo_c, '1', tx_uq, '1']
- [tx_ui, '0', tx_ssb, '0']
- [tx_uq, '0', tx_ssb, '1']
- [tx_ssb, '0', rx_mi, '0']
- [tx_ssb, '0', rx_mq, '0']
- [rx_lo_c, '0', rx_mi, '1']
- [rx_lo_c, '1', rx_mq, '1']
- [rx_mi, '0', rx_lpi, '0']
- [rx_mq, '0', rx_lpq, '0']
- [rx_lpi, '0', rx_ui, '0']
- [rx_lo_a, '0', rx_ui, '1']
- [rx_lpq, '0', rx_uq, '0']
- [rx_lo_a, '1', rx_uq, '1']
- [rx_ui, '0', rx_aud, '0']
- [rx_uq, '0', rx_aud, '1']
- [rx_aud, '0', g4, '0']
- [g4, '0', msink, '0']
- [msink, '0', out_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
