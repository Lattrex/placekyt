options:
  parameters:
    author: Kyttar
    description: 'FULL on-chip SSB Weaver TRANSCEIVER built from REAL blocks (4 real multipliers + a subtract per half, exactly the Weaver diagram). audio -> NCO(fa) mixers -> 2x LowPass -> NCO(fc) mixers -> Subtract [SSB] -> NCO(fc) mixers -> 2x LowPass -> NCO(fa) mixers -> Subtract -> Gain -> recovered audio. Imports into placeKYT: two clean real filaments, no complex-block fan-in. Run as GNURadio Server in placeKYT + Execute here to stream audio.'
    generate_options: qt_gui
    id: ssb_weaver_transceiver
    output_language: python
    title: SSB Weaver transceiver (on-chip, real blocks) — audio in vs recovered
  states: {}

blocks:
- name: n_samp
  id: variable
  parameters:
    comment: audio burst length
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000.0'
  states: {}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT GNURadio-server port
    value: '58950'
  states: {}
- name: audio
  id: blocks_add_xx
  parameters:
    comment: input audio (2 tones)
    type: float
  states: {}
- name: g4
  id: kyttar_gain
  parameters:
    comment: Weaver 1/4 -> x4
    device_id: '"kyttar_0"'
    gain: '4'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import ssb_demo_stim as stim
  states: {}
- name: in_sink
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: input audio
    name: Input audio
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: out_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: recovered audio
    name: Recovered audio (chip out)
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: pb_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: SSB passband
    name: TX passband (SSB, chip out)
    size: n_samp
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    yunit: ''
  states: {}
- name: rx_f2c
  id: blocks_float_to_complex
  parameters:
    comment: passband -> I (Q=0)
  states: {}
- name: rx_lp
  id: kyttar_complex_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    device_id: '"kyttar_0"'
    gain: '0.9'
    samp_rate: samp_rate
    transition_width: '2500.0'
    window: '"hamming"'
  states: {}
- name: rx_mc
  id: kyttar_complex_mixer
  parameters:
    block_name: '"complexmixer_2"'
    amplitude: '1.0'
    device_id: '"kyttar_0"'
    frequency: '-6000.0'
    offset: '0.0'
    phase: '-20.02765316663493'
    sample_rate: '32000.0'
  states: {}
- name: rx_q0
  id: blocks_null_source
  parameters:
    comment: Q = 0
    type: float
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered audio <- x16_out (RX chain, stream rx)
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: SSB passband -> chip x16_in (RX chain, stream rx)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"rx"'
  states: {}
- name: rx_up
  id: kyttar_iq_upconvert
  parameters:
    block_name: '"iqupconvert_2"'
    device_id: '"kyttar_0"'
    frequency: '1500.0'
    sample_rate: '32000.0'
  states: {}
- name: ssb_rf
  id: blocks_vector_source_x
  parameters:
    comment: 'RX input: the SSB passband (same audio); finite, no repeat'
    repeat: 'False'
    type: float
    vector: stim.ssb_passband(n_samp)
  states: {}
- name: thr
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: tone2
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: '1800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: tx_f2c
  id: blocks_float_to_complex
  parameters:
    comment: audio -> I (Q=0)
  states: {}
- name: tx_lp
  id: kyttar_complex_low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '1200.0'
    device_id: '"kyttar_0"'
    gain: '0.9'
    samp_rate: samp_rate
    transition_width: '2500.0'
    window: '"hamming"'
  states: {}
- name: tx_ma
  id: kyttar_complex_mixer
  parameters:
    block_name: '"complexmixer"'
    amplitude: '1.0'
    device_id: '"kyttar_0"'
    frequency: '-1500.0'
    offset: '0.0'
    phase: '-9.130253649495335'
    sample_rate: '32000.0'
  states: {}
- name: tx_q0
  id: blocks_null_source
  parameters:
    comment: Q = 0
    type: float
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: SSB passband <- x16_out (TX chain, stream tx)
    device_id: '"kyttar_0"'
    hold_secs: '5.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: server_port
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    burst_len: n_samp
    comment: audio -> chip x16_in (TX chain, stream tx)
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    pipelined: 'yes'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
    stream_id: '"tx"'
  states: {}
- name: tx_up
  id: kyttar_iq_upconvert
  parameters:
    block_name: '"iqupconvert"'
    device_id: '"kyttar_0"'
    frequency: '6000.0'
    sample_rate: '32000.0'
  states: {}

connections:
- [audio, '0', thr, '0']
- [g4, '0', rx_sink, '0']
- [rx_f2c, '0', rx_mc, '0']
- [rx_lp, '0', rx_up, '0']
- [rx_mc, '0', rx_lp, '0']
- [rx_q0, '0', rx_f2c, '1']
- [rx_sink, '0', out_sink, '0']
- [rx_src, '0', rx_f2c, '0']
- [rx_up, '0', g4, '0']
- [ssb_rf, '0', rx_src, '0']
- [thr, '0', in_sink, '0']
- [thr, '0', tx_src, '0']
- [tone, '0', audio, '0']
- [tone2, '0', audio, '1']
- [tx_f2c, '0', tx_ma, '0']
- [tx_lp, '0', tx_up, '0']
- [tx_ma, '0', tx_lp, '0']
- [tx_q0, '0', tx_f2c, '1']
- [tx_sink, '0', pb_sink, '0']
- [tx_src, '0', tx_f2c, '0']
- [tx_up, '0', tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
