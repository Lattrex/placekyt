options:
  parameters:
    author: Lattrex
    description: 'TRIPLE-MODULAR REDUNDANCY on one placeKYT array, next to an ordinary single-path stream on the SAME die. A 256-byte ramp fans out to three identical identity workers (Stream Splitter relays); a depth-neutral fault injector (Kyttar Add Const) sits on EVERY arm with constants 0 / f / 0, so the f variable (one byte LSB in signal units, 1/32768) corrupts path B by exactly one word without changing any arm''s depth; set f to 0.0 for the healthy run. The TMR Voter tells the arms apart by arrival face, votes, and emits a 2-word [value, status] packet per sample: with f=0 every packet is [ramp byte, 0]; with the fault every packet is [ramp byte, 2] — the value is STILL the correct ramp byte (TMR corrects the fault) and the status names path B. A second, independent stream rides the same array through a single Gain block (0.5x), demonstrating that redundancy is chosen PER PATH at place-and-route time: TMR for the safety-critical path, single-path for the rest, same die. Both kyttar sources set Output words = Raw (byte and status words are not Q15). Change f, re-import into placeKYT to rebuild, and re-run to compare.'
    generate_options: qt_gui
    id: tmr_pipeline
    output_language: python
    title: TMR pipeline (triple-redundant path + single path, one array)
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    comment: 'fault injected on path B, in signal units. 3.0517578125e-05 = 1/32768 = exactly ONE word LSB (all packets [byte, 2] - value still correct); 0.0 = healthy (all packets [byte, 0]). A float literal, NOT an expression: the placeKYT importer resolves a marker param through one variable lookup and keeps the block default for anything it cannot literal-coerce.'
    value: '3.0517578125e-05'
  states: {}
- name: burst_len
  id: variable
  parameters:
    comment: ramp length in bytes
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: display rate for the time sinks
    value: '8000'
  states: {}
- name: ramp_tmr
  id: blocks_vector_source_x
  parameters:
    comment: the protected stream's stimulus - a 256-byte ramp
    repeat: 'False'
    type: byte
    vector: list(range(burst_len))
  states: {}
- name: b2f_tmr
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: to_raw_tmr
  id: blocks_multiply_const_vxx
  parameters:
    comment: kyttar.source expects q15/32768 floats
    const: 1.0/32768.0
    type: float
  states: {}
- name: tmr_src
  id: kyttar_source
  parameters:
    comment: 'the TMR stream. Output words = Raw: byte values and status codes are words, not Q15 samples'
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"raw"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tmr"'
  states: {}
- name: split
  id: kyttar_splitter
  parameters:
    comment: 3-way fan-out onto the three redundant arms
    device_id: '"kyttar_0"'
  states: {}
- name: worker_a
  id: kyttar_splitter
  parameters:
    comment: redundant worker A - an exact, memoryless identity relay
    device_id: '"kyttar_0"'
  states: {}
- name: worker_b
  id: kyttar_splitter
  parameters:
    comment: redundant worker B
    device_id: '"kyttar_0"'
  states: {}
- name: worker_c
  id: kyttar_splitter
  parameters:
    comment: redundant worker C
    device_id: '"kyttar_0"'
  states: {}
- name: inj_a
  id: kyttar_add_const
  parameters:
    comment: 'depth-neutral fault injector, path A: const 0 (healthy)'
    const: '0.0'
    device_id: '"kyttar_0"'
  states: {}
- name: inj_b
  id: kyttar_add_const
  parameters:
    comment: 'depth-neutral fault injector, path B: adds f (0.0 = healthy, 1/32768 = one-word fault)'
    const: f
    device_id: '"kyttar_0"'
  states: {}
- name: inj_c
  id: kyttar_add_const
  parameters:
    comment: 'depth-neutral fault injector, path C: const 0 (healthy)'
    const: '0.0'
    device_id: '"kyttar_0"'
  states: {}
- name: voter
  id: kyttar_tmr_voter
  parameters:
    comment: majority vote + [value, status] packet per sample
    device_id: '"kyttar_0"'
    fault_sentinel: '65535'
  states: {}
- name: tmr_sink
  id: kyttar_sink
  parameters:
    comment: drains the [value, status] packet stream (raw words)
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"tmr"'
  states: {}
- name: deint
  id: blocks_deinterleave
  parameters:
    comment: 'splits the 2-word packets: out0 = voted values, out1 = status codes'
    type: float
  states: {}
- name: values_scope
  id: qtgui_time_sink_x
  parameters:
    comment: 'voted values: the ramp 0..255, faulted or not'
    name: '"voted values (the ramp, fault corrected)"'
    size: burst_len
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: byte value
    ymax: '256'
    ymin: '0'
  states: {}
- name: status_scope
  id: qtgui_time_sink_x
  parameters:
    color1: red
    comment: 'status codes: 0 = all agree, 2 = path B faulted (and corrected)'
    name: '"vote status (0 = agree, 2 = path B faulted)"'
    size: burst_len
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: status code
    ymax: '8'
    ymin: '-0.5'
  states: {}
- name: ramp_solo
  id: blocks_vector_source_x
  parameters:
    comment: the ordinary (non-redundant) stream's stimulus - the same ramp
    repeat: 'False'
    type: byte
    vector: list(range(burst_len))
  states: {}
- name: b2f_solo
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: to_raw_solo
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {}
- name: solo_src
  id: kyttar_source
  parameters:
    comment: 'the single-path stream: same array, same run, no redundancy'
    burst_len: burst_len
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    output_words: '"raw"'
    pipelined: 'no'
    port_name: '"x16_in"'
    repeat: 'no'
    schedule: '"interleaved"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"solo"'
  states: {}
- name: solo_gain
  id: kyttar_gain
  parameters:
    comment: an ordinary single-path DSP stage (0.5x)
    block_name: '""'
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: solo_sink
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    in_type: float
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'True'
    stream_id: '"solo"'
  states: {}
- name: solo_scope
  id: qtgui_time_sink_x
  parameters:
    color1: green
    comment: the single-path stream's output (0.5x the ramp)
    name: '"single-path stream (0.5x ramp, same array)"'
    size: burst_len
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: word value
    ymax: '160'
    ymin: '0'
  states: {}

connections:
- [ramp_tmr, '0', b2f_tmr, '0']
- [b2f_tmr, '0', to_raw_tmr, '0']
- [to_raw_tmr, '0', tmr_src, '0']
- [tmr_src, '0', split, '0']
- [split, '0', worker_a, '0']
- [split, '0', worker_b, '0']
- [split, '0', worker_c, '0']
- [worker_a, '0', inj_a, '0']
- [worker_b, '0', inj_b, '0']
- [worker_c, '0', inj_c, '0']
- [inj_a, '0', voter, '0']
- [inj_b, '0', voter, '1']
- [inj_c, '0', voter, '2']
- [voter, '0', tmr_sink, '0']
- [tmr_sink, '0', deint, '0']
- [deint, '0', values_scope, '0']
- [deint, '1', status_scope, '0']
- [ramp_solo, '0', b2f_solo, '0']
- [b2f_solo, '0', to_raw_solo, '0']
- [to_raw_solo, '0', solo_src, '0']
- [solo_src, '0', solo_gain, '0']
- [solo_gain, '0', solo_sink, '0']
- [solo_sink, '0', solo_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
