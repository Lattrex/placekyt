options:
  parameters:
    author: Lattrex
    description: 'ONE importable design of REAL Kyttar blocks. The TX chain (PSK mapper -> upsampler -> RRC -> I/Q upconvert) and the coherent RX chain (complex RRC matched filter -> Costas -> Gardner -> BPSK slicer) both live on ONE placeKYT array. GRC closes the loop: the TX passband leaves the chip, is downconverted to complex baseband in stock GR (the ''channel''), AWGN is added (noise_volt variable; 0 = clean, BER 0), and it re-enters as the RX input -> recovered bits == transmitted bits. Raise noise_volt live to watch the constellation smear and the BER climb. Import into placeKYT (File -> Import GNURadio Flowgraph): all 8 DSP blocks place on the chip; the GR downconvert + AWGN channel are dropped. Then ''Run as GNURadio Server'' + Execute this graph.'
    generate_options: qt_gui
    id: bpsk_loopback
    output_language: python
    title: BPSK transceiver loopback (TX -> upconvert -> downconvert -> RX) on one chip
  states: {}

blocks:
- name: sps
  id: variable
  parameters:
    comment: TX samples per symbol
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: TX passband sample rate
    value: '32000'
  states: {}
- name: carrier
  id: variable
  parameters:
    comment: TX carrier frequency
    value: '4000'
  states: {}
- name: import_stim
  id: import
  parameters:
    imports: from gnuradio.kyttar import modem_demo_stim as stim
  states: {}
- name: n_syms
  id: variable
  parameters:
    comment: RX symbols in the burst
    value: '120'
  states: {}
- name: n_bits
  id: variable
  parameters:
    comment: TX bits in the burst
    value: '64'
  states: {}
- name: tx_src
  id: kyttar_source
  parameters:
    comment: TX bits -> placeKYT chip x16_in (shared duplex port, stream 'tx')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"tx"'
    burst_len: n_bits
  states: {}
- name: mapper
  id: kyttar_psk_symbol_mapper
  parameters:
    comment: PSK symbol mapper (BPSK) — placed on chip
    device_id: '"kyttar_0"'
    modulation: '"bpsk"'
  states: {}
- name: up
  id: kyttar_upsampler
  parameters:
    comment: Zero-stuff upsampler (sps) — placed on chip
    device_id: '"kyttar_0"'
    sps: sps
  states: {}
- name: rrc
  id: kyttar_rrc_pulse_shaper
  parameters:
    alpha: '0.35'
    comment: RRC pulse shaper — placed on chip
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: upc
  id: kyttar_iq_upconvert
  parameters:
    comment: I/Q upconvert to real passband — placed on chip
    device_id: '"kyttar_0"'
    frequency: carrier
    sample_rate: samp_rate
  states: {}
- name: tx_sink
  id: kyttar_sink
  parameters:
    comment: TX passband -> placeKYT chip x16_out (shared duplex port, stream 'tx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"tx"'
  states: {}
- name: rx_src
  id: kyttar_source
  parameters:
    comment: RX I/Q baseband (from the downconverted TX passband) -> matched filter
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '58950'
    stream_id: '"rx"'
    burst_len: n_bits*4//2 - 1
  states: {}
- name: mf
  id: kyttar_complex_rrc_matched_filter
  parameters:
    alpha: '0.35'
    comment: Complex RRC matched filter front end — placed on chip
    device_id: '"kyttar_0"'
    span: '8'
  states: {}
- name: costas
  id: kyttar_costas_loop
  parameters:
    comment: Complex Costas carrier recovery — placed on chip
    damping: '1.0'
    device_id: '"kyttar_0"'
    loop_bw: '0.05'
  states: {}
- name: gardner
  id: kyttar_gardner_ted
  parameters:
    comment: Gardner timing recovery — placed on chip
    device_id: '"kyttar_0"'
    ki: '1'
    kp: '3'
  states: {}
- name: slicer
  id: kyttar_bpsk_slicer
  parameters:
    comment: BPSK slicer (recovered bits) — placed on chip
    device_id: '"kyttar_0"'
  states: {}
- name: rx_sink
  id: kyttar_sink
  parameters:
    comment: recovered bits -> placeKYT chip x16_out (shared duplex port, stream 'rx')
    device_id: '"kyttar_0"'
    hold_secs: '8.0'
    num_channels: '1'
    port_name: '"x16_out"'
    server_port: '58950'
    server_repeat: 'False'
    stream_id: '"rx"'
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bit stimulus (one finite burst -> EOF dispatches it; no repeat)
    type: float
    vector: stim.tx_bits(n_bits)
    repeat: 'False'
  states: {}
- name: tx_passband
  id: qtgui_time_sink_x
  parameters:
    comment: TX passband (real) — recovered from the chip x16_out (stream 'tx')
    type: float
    name: '"TX passband (real)"'
    ylabel: amplitude
  states: {}
- name: rx_bits
  id: qtgui_time_sink_x
  parameters:
    comment: recovered bits — from the chip x16_out (stream 'rx')
    type: float
    name: '"Recovered bits"'
    ylabel: bit
  states: {}
- name: f2c
  id: blocks_float_to_complex
  parameters:
    comment: TX passband (real) -> complex (imag = 0)
  states: {}
- name: lo
  id: analog_sig_source_x
  parameters:
    amp: '2.0'
    comment: LO = 2*exp(-j*2*pi*(carrier/samp_rate)*n) (image-reject gain 2.0); skiphead(1) absorbs the upconvert NCO increment-before-emit.
    freq: '-carrier'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mix
  id: blocks_multiply_xx
  parameters:
    comment: downconvert to complex baseband
    type: complex
  states: {}
- name: skip
  id: blocks_skiphead
  parameters:
    comment: bb[1:] (exact 1-sample delay; not blocks.delay)
    num_items: '1'
    type: complex
  states: {}
- name: keep
  id: blocks_keep_one_in_n
  parameters:
    comment: bb[::2] (decimate TX sps 4 -> RX sps 2)
    n: '2'
    type: complex
  states: {}
- name: noise_volt
  id: variable
  parameters:
    comment: AWGN std-dev on the baseband I/Q (0 = clean). Raise live to degrade BER + smear the constellation.
    value: '0.0'
  states: {}
- name: awgn
  id: analog_noise_source_x
  parameters:
    amp: noise_volt
    comment: complex AWGN (channel noise)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: chan
  id: blocks_add_xx
  parameters:
    comment: baseband + AWGN -> noisy RX input
    type: complex
  states: {}
- name: const_sink
  id: qtgui_const_sink_x
  parameters:
    comment: downconverted BPSK constellation (2 clean points)
    label1: baseband
    name: '"Downconverted constellation"'
    size: '1024'
    tr_slope: qtgui.TRIG_MODE_POS
    type: complex
  states: {}

connections:
- [costas, '0', gardner, '0']
- [gardner, '0', slicer, '0']
- [mapper, '0', up, '0']
- [mf, '0', costas, '0']
- [rrc, '0', upc, '0']
- [rx_src, '0', mf, '0']
- [slicer, '0', rx_sink, '0']
- [tx_src, '0', mapper, '0']
- [up, '0', rrc, '0']
- [upc, '0', tx_sink, '0']
- [tx_bits, '0', tx_src, '0']
- [tx_sink, '0', tx_passband, '0']
- [rx_sink, '0', rx_bits, '0']
- [tx_sink, '0', f2c, '0']
- [f2c, '0', mix, '0']
- [lo, '0', mix, '1']
- [mix, '0', skip, '0']
- [skip, '0', keep, '0']
- [keep, '0', chan, '0']
- [awgn, '0', chan, '1']
- [chan, '0', rx_src, '0']
- [chan, '0', const_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
