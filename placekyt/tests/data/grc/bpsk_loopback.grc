options:
  parameters:
    author: Lattrex
    description: 'BPSK transceiver PASSBAND LOOPBACK. A DRIVER flowgraph (NOT a placeKYT chip design): it drives a placeKYT-hosted chip that has BOTH a TX and an RX chain (the bpsk_modem design). TX bits -> kyttar.chip_batch[tx] -> REAL passband (carrier = fs/8) -> downconvert in stock GR (float_to_complex * sig_source, image-reject gain 2.0, skiphead(1) + keep_one_in_n(2)) -> kyttar.chip_batch[rx] -> recovered bits. Closes the loop: bits in == bits out (BER 0). Run placeKYT''s ''Run as GNURadio Server'' on the bpsk_modem design, set Host/Port to match, then Execute this.'
    generate_options: qt_gui
    id: bpsk_loopback
    output_language: python
    title: BPSK transceiver passband loopback (TX -> upconvert -> downconvert -> RX)
  states: {}

blocks:
- name: n_bits
  id: variable
  parameters:
    comment: TX bits in the burst
    value: '64'
  states: {}
- name: fs
  id: variable
  parameters:
    comment: passband sample rate (Hz)
    value: '32000'
  states: {}
- name: carrier
  id: variable
  parameters:
    comment: carrier = fs/8 -> 0.125 cyc/sample
    value: '4000'
  states: {}
- name: sps_tx
  id: variable
  parameters:
    comment: TX samples-per-symbol
    value: '4'
  states: {}
- name: host
  id: variable
  parameters:
    comment: placeKYT GNURadio server host
    value: '"127.0.0.1"'
  states: {}
- name: port
  id: variable
  parameters:
    comment: placeKYT GNURadio server port
    value: '58950'
  states: {}
- name: import_stim
  id: import
  parameters:
    comment: TX bit stimulus
    imports: from gnuradio.kyttar import modem_demo_stim as stim
  states: {}
- name: tx_bits
  id: blocks_vector_source_x
  parameters:
    comment: TX bits (+ pad so the rate-expanding chip_batch[tx] drains all 256 passband words live)
    repeat: 'False'
    type: float
    vector: '[float(b) for b in stim.tx_bits(n_bits)] + [0.0]*512'
  states: {}
- name: tx_chip
  id: kyttar_chip_batch
  parameters:
    comment: 'TX chain on the hosted chip: bits -> real passband'
    host: host
    port: port
    stream_id: '"tx"'
    in_kind: real
    out_kind: real
    in_port: '"x16_in"'
    out_port: '"x16_out"'
    data_addr0: '0'
    data_addr1: '1'
    raw: 'False'
    burst_len: n_bits
  states: {}
- name: f2c
  id: blocks_float_to_complex
  parameters:
    comment: real passband -> complex (imag = 0)
  states: {}
- name: lo
  id: analog_sig_source_x
  parameters:
    amp: '2.0'
    comment: LO = 2*exp(-j*2*pi*0.125*n) (image-reject gain 2.0); freq=-carrier, phase=0 (skiphead(1) absorbs the NCO increment-before-emit delay-1)
    freq: '-carrier'
    offset: '0'
    phase: '0'
    samp_rate: fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: mix
  id: blocks_multiply_xx
  parameters:
    comment: bb = 2*pb*exp(-j*2*pi*0.125*n)
    type: complex
  states: {}
- name: skip
  id: blocks_skiphead
  parameters:
    comment: 'bb[1:]  (delay 1: exact, not blocks.delay)'
    num_items: '1'
    type: complex
  states: {}
- name: keep
  id: blocks_keep_one_in_n
  parameters:
    comment: bb[::2]  (decimate sps 4 -> RX sps 2)
    n: '2'
    type: complex
  states: {}
- name: rx_chip
  id: kyttar_chip_batch
  parameters:
    comment: 'RX chain on the hosted chip: complex baseband -> bits'
    host: host
    port: port
    stream_id: '"rx"'
    in_kind: complex
    out_kind: real
    in_port: '"x16_in"'
    out_port: '"x16_out"'
    data_addr0: '0'
    data_addr1: '1'
    raw: 'True'
    burst_len: n_bits*sps_tx//2-1
  states: {}
- name: bit_sink
  id: qtgui_time_sink_x
  parameters:
    comment: recovered bits (loopback out)
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: recovered bit
    name: '"Recovered bits (loopback)"'
    size: '128'
    srate: '1'
    type: float
    ylabel: bit
    ymax: '1.3'
    ymin: '-0.3'
  states: {}
- name: pb_sink
  id: qtgui_time_sink_x
  parameters:
    comment: TX passband (real)
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: passband
    name: '"TX passband"'
    size: '128'
    srate: '1'
    type: float
    ylabel: bit
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: const_sink
  id: qtgui_const_sink_x
  parameters:
    comment: downconverted BPSK constellation (2 clean points)
    gui_hint: 1,1,1,1
    label1: baseband
    name: '"Downconverted constellation"'
    size: '1024'
    tr_slope: qtgui.TRIG_MODE_POS
    type: complex
  states: {}

connections:
- [tx_bits, '0', tx_chip, '0']
- [tx_chip, '0', f2c, '0']
- [tx_chip, '0', pb_sink, '0']
- [f2c, '0', mix, '0']
- [lo, '0', mix, '1']
- [mix, '0', skip, '0']
- [skip, '0', keep, '0']
- [keep, '0', rx_chip, '0']
- [keep, '0', const_sink, '0']
- [rx_chip, '0', bit_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
