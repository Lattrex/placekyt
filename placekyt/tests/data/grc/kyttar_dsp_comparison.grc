options:
  parameters:
    author: Lattrex
    description: Compare Kyttar DSP blocks with standard GNURadio blocks
    generate_options: qt_gui
    id: kyttar_dsp_comparison
    output_language: python
    title: Kyttar DSP Comparison
  states: {}

blocks:
- name: agc_rate
  id: variable
  parameters:
    comment: AGC adaptation rate
    value: '0.01'
  states: {}
- name: agc_target
  id: variable
  parameters:
    comment: AGC target level
    value: '0.7'
  states: {}
- name: dc_offset
  id: variable
  parameters:
    comment: DC offset added to signal
    value: '0.2'
  states: {}
- name: fir_taps
  id: variable
  parameters:
    comment: FIR filter taps (3-tap lowpass)
    value: '[0.25, 0.5, 0.25]'
  states: {}
- name: output_gain
  id: variable
  parameters:
    comment: Post-Kyttar gain boost
    value: '3.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: Sine wave + DC offset
    freq: '500'
    offset: dc_offset
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Reference DC Blocker
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: agc_rate
    comment: Reference AGC
    decay_rate: agc_rate
    gain: '0.5'
    max_gain: '10'
    reference: agc_target
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Reference FIR Filter
    decim: '1'
    taps: fir_taps
    type: fff
  states: {}
- name: kyttar_dc_blocker_0
  id: kyttar_dc_blocker
  parameters:
    comment: Kyttar DC Blocker
    device_id: '"kyttar_0"'
    length: '2'
    long_form: 'False'
  states: {}
- name: kyttar_device_0
  id: kyttar_device
  parameters:
    chip_type: '"12x12_dev"'
    comment: Kyttar Device Configuration
    device_id: '"kyttar_0"'
  states: {}
- name: kyttar_fir_filter_0
  id: kyttar_fir_filter
  parameters:
    coefficients: fir_taps
    comment: Kyttar FIR Filter
    device_id: '"kyttar_0"'
  states: {}
- name: kyttar_agc_0
  id: kyttar_agc
  parameters:
    comment: Kyttar AGC
    device_id: '"kyttar_0"'
    initial_gain: '0.5'
    rate: agc_rate
    target: agc_target
  states: {}
- name: kyttar_sink_0
  id: kyttar_sink
  parameters:
    comment: Exit from Kyttar chip
    device_id: '"kyttar_0"'
    port_name: '"x16_out"'
  states: {}
- name: blocks_multiply_const_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Post-chip gain boost
    const: output_gain
    type: float
  states: {}
- name: kyttar_source_0
  id: kyttar_source
  parameters:
    comment: Entry into Kyttar chip
    device_id: '"kyttar_0"'
    port_name: '"x16_in"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency domain comparison
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: Input
    label2: Kyttar
    label3: Reference
    name: '"Frequency Comparison"'
    nconnections: '3'
    type: float
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Compare Kyttar vs Reference outputs
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: Input (with DC)
    label2: Kyttar Output
    label3: Reference Output
    name: '"DSP Comparison"'
    nconnections: '3'
    size: '2048'
    srate: samp_rate
    type: float
    width2: '2'
    width3: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle_0, '0', kyttar_source_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '2']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_0, '2']
- [kyttar_dc_blocker_0, '0', kyttar_fir_filter_0, '0']
- [kyttar_fir_filter_0, '0', kyttar_agc_0, '0']
- [kyttar_agc_0, '0', kyttar_sink_0, '0']
- [kyttar_sink_0, '0', blocks_multiply_const_0, '0']
- [blocks_multiply_const_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_0, '0', qtgui_time_sink_x_0, '1']
- [kyttar_source_0, '0', kyttar_dc_blocker_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
