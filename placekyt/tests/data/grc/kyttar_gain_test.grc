options:
  parameters:
    author: Lattrex
    description: Simple test of Kyttar Gain block
    generate_options: qt_gui
    id: kyttar_gain_test
    output_language: python
    title: Kyttar Gain Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: kyttar_device_0
  id: kyttar_device
  parameters:
    chip_type: '"12x12_dev"'
    comment: |-
      Kyttar Device Configuration
      (No signal connections needed)
    device_id: '"kyttar_0"'
  states: {}
- name: kyttar_gain_0
  id: kyttar_gain
  parameters:
    device_id: '"kyttar_0"'
    gain: '0.5'
  states: {}
- name: kyttar_sink_0
  id: kyttar_sink
  parameters:
    device_id: '"kyttar_0"'
    port_name: '"x16_out"'
  states: {}
- name: kyttar_source_0
  id: kyttar_source
  parameters:
    device_id: '"kyttar_0"'
    port_name: '"x16_in"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Input
    label2: Output (Gain=0.5)
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', kyttar_source_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [kyttar_gain_0, '0', kyttar_sink_0, '0']
- [kyttar_sink_0, '0', qtgui_time_sink_x_0, '1']
- [kyttar_source_0, '0', kyttar_gain_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
