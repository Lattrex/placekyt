options:
  parameters:
    author: Lattrex
    description: 'All-flavors float<->complex converter demo, structured so it RUNS end to end on a placeKYT-hosted chip. ONE complex stream is fed in, split to two real rails, gained, recombined, and read back — so every float/complex converter is exercised AND the output is directly verifiable (identity chain: the mixers are pass-through, so chip output == input). Chain: complex source (x16_in) -> complex mixer -> blocks_complex_to_float (split I/Q) -> two real gains -> blocks_float_to_complex (recombine the two on-chip real rails via the DualFloatToComplex block) -> complex mixer -> blocks_complex_to_real -> real gain -> sink (x16_out). The two reals feeding the recombine come from the on-chip c2f split (a normal fan-in), NOT two independent input ports, so no input splitter is needed. Run: ''Run as GNURadio Server'' in placeKYT, set server_port below to the printed port, then Execute here; the time sink overlays the input against the chip output so the round trip is visible.'
    generate_options: qt_gui
    id: converter_flavors
    output_language: python
    title: Float<->Complex converter flavors (runnable identity chain)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {bus_structure: 'null'}
- name: burst_len
  id: variable
  parameters:
    comment: float samples dispatched to the chip in one batch RPC
    value: '256'
  states: {bus_structure: 'null'}
- name: server_port
  id: variable
  parameters:
    comment: placeKYT prints this on "Run as GNURadio Server"
    value: '58950'
  states: {bus_structure: 'null'}
- name: src_wave
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    comment: complex rotating phasor stimulus
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {bus_structure: 'null'}
- name: src_head
  id: blocks_head
  parameters:
    comment: bound the stream to one burst so the batch source dispatches once
    num_items: burst_len
    type: complex
  states: {bus_structure: 'null'}
- name: msrc
  id: kyttar_source
  parameters:
    burst_len: burst_len
    comment: complex stimulus -> placeKYT chip x16_in (batch)
    complex_in: complex
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: server_port
  states: {bus_structure: 'null'}
- name: mix1
  id: kyttar_complex_mixer
  parameters:
    amplitude: '1.0'
    comment: pass-through (freq 0)
    device_id: '"kyttar_0"'
    frequency: '0'
    offset: '0.0'
    phase: '0.0'
    sample_rate: '32000'
  states: {bus_structure: 'null'}
- name: c2f
  id: blocks_complex_to_float
  parameters:
    comment: split complex -> (I
  states: {bus_structure: 'null'}
- name: gain_i
  id: kyttar_gain
  parameters:
    comment: I rail
    device_id: '"kyttar_0"'
    gain: '1'
  states: {bus_structure: 'null'}
- name: gain_q
  id: kyttar_gain
  parameters:
    comment: Q rail
    device_id: '"kyttar_0"'
    gain: '1'
  states: {bus_structure: 'null'}
- name: f2c
  id: blocks_float_to_complex
  parameters:
    comment: recombine (I
  states: {bus_structure: 'null'}
- name: mix2
  id: kyttar_complex_mixer
  parameters:
    amplitude: '1.0'
    comment: pass-through (freq 0)
    device_id: '"kyttar_0"'
    frequency: '0'
    offset: '0.0'
    phase: '0.0'
    sample_rate: '32000'
  states: {bus_structure: 'null'}
- name: c2r
  id: blocks_complex_to_real
  parameters:
    comment: complex -> real (I)
  states: {bus_structure: 'null'}
- name: gain_out
  id: kyttar_gain
  parameters:
    comment: output gain
    device_id: '"kyttar_0"'
    gain: '1'
  states: {bus_structure: 'null'}
- name: msink
  id: kyttar_sink
  parameters:
    comment: chip x16_out -> back to GRC
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_out"'
    server_host: '"127.0.0.1"'
    server_port: server_port
  states: {bus_structure: 'null'}
- name: c2f_ref
  id: blocks_complex_to_float
  parameters:
    comment: reference I of the input for the overlay
  states: {bus_structure: 'null'}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: input I (ref) vs chip output I
    grid: 'True'
    label1: chip out (I)
    label2: input (I ref)
    name: '"Converter chain: input I vs chip output (identity)"'
    nconnections: '2'
    size: '256'
    srate: samp_rate
    type: float
  states: {bus_structure: 'null'}

connections:
- [src_wave, '0', src_head, '0']
- [src_head, '0', msrc, '0']
- [msrc, '0', mix1, '0']
- [mix1, '0', c2f, '0']
- [c2f, '0', gain_i, '0']
- [c2f, '1', gain_q, '0']
- [gain_i, '0', f2c, '0']
- [gain_q, '0', f2c, '1']
- [f2c, '0', mix2, '0']
- [mix2, '0', c2r, '0']
- [c2r, '0', gain_out, '0']
- [gain_out, '0', msink, '0']
- [msink, '0', time_sink, '0']
- [src_head, '0', c2f_ref, '0']
- [c2f_ref, '0', time_sink, '1']

metadata:
  file_format: 1
  grc_version: 3.10.0
