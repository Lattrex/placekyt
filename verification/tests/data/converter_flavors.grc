options:
  parameters:
    author: Lattrex
    description: 'Standalone all-flavors float<->complex converter test flowgraph. ONE linear chain threading EVERY float/complex dtype interaction the placeKYT importer handles, so the coverage is visible in one importable .grc that runs headless and in the placeKYT GUI. Flavors, in order along the chain: (1) two real streams (srcI, srcQ) -> blocks_float_to_complex (2-real) -> a physical DualFloatToComplex LOCK-rendezvous block -> a complex mixer; (2) complex mixer -> blocks_complex_to_float (both rails) -> out_i and out_q each drive a real gain; (3) the out_i real rail -> blocks_float_to_complex (single real, Q = null_source) -> a second complex mixer (xq treated as 0); (4) the second complex mixer -> blocks_complex_to_real (drop Q) -> a real gain -> sink. Every float<->complex boundary is resolved by a stock GR converter so the graph is grcc-clean; the placeKYT importer CONSUMES the logical converters (single-real f2c, complex_to_real, complex_to_float) as zero cells and inserts one physical DualFloatToComplex cell for the 2-real f2c. NOTE: this graph exercises the placeKYT import path; the kyttar source/sink talk to a placeKYT server, so it is not meant to run as a standalone GNU Radio flowgraph.'
    generate_options: qt_gui
    id: converter_flavors
    output_language: python
    title: Float<->Complex converter flavors (all combinations, one chain)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: n_samp
  id: variable
  parameters:
    value: '256'
  states: {}
- name: feedI
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: I feeder
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: feedQ
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: Q feeder
    freq: '250'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: consumer
  id: blocks_null_sink
  parameters:
    bus_structure_sink: ''
    comment: dev-null for the chip output
    type: float
  states: {}
- name: qsink
  id: kyttar_sink
  parameters:
    comment: Q rail observed -> chip x16_out (stream 'q_obs')
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_out"'
    server_host: '"127.0.0.1"'
    server_port: '0'
    stream_id: '"q_obs"'
  states: {}
- name: qconsumer
  id: blocks_null_sink
  parameters:
    bus_structure_sink: ''
    comment: dev-null for the Q-rail observation
    type: float
  states: {}
- name: srcI
  id: kyttar_source
  parameters:
    comment: I stream -> chip x16_in (stream 'i')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '0'
    stream_id: '"i"'
    burst_len: n_samp
  states: {}
- name: srcQ
  id: kyttar_source
  parameters:
    comment: Q stream -> chip x16_in (stream 'q')
    complex_in: float
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_in"'
    server_host: '"127.0.0.1"'
    server_port: '0'
    stream_id: '"q"'
    burst_len: n_samp
  states: {}
- name: f2c_dual
  id: blocks_float_to_complex
  parameters:
    comment: 2-real -> DualFloatToComplex (LOCK rendezvous)
  states: {}
- name: mix1
  id: kyttar_complex_mixer
  parameters:
    amplitude: '1.0'
    comment: complex DSP stage 1
    device_id: '"kyttar_0"'
    frequency: '-1500'
    offset: '0.0'
    phase: '0.0'
    sample_rate: '32000'
  states: {}
- name: c2f
  id: blocks_complex_to_float
  parameters:
    comment: complex_to_float (both rails)
  states: {}
- name: gain_i
  id: kyttar_gain
  parameters:
    comment: I rail gain
    device_id: '"kyttar_0"'
    gain: '1'
  states: {}
- name: gain_q
  id: kyttar_gain
  parameters:
    comment: Q rail gain
    device_id: '"kyttar_0"'
    gain: '1'
  states: {}
- name: nullq
  id: blocks_null_source
  parameters:
    bus_structure_source: ''
    comment: Q = 0 for the single-real f2c
    type: float
  states: {}
- name: f2c_single
  id: blocks_float_to_complex
  parameters:
    comment: single-real f2c (Q = null_source -> xq = 0)
  states: {}
- name: mix2
  id: kyttar_complex_mixer
  parameters:
    amplitude: '1.0'
    comment: complex DSP stage 2
    device_id: '"kyttar_0"'
    frequency: '1500'
    offset: '0.0'
    phase: '0.0'
    sample_rate: '32000'
  states: {}
- name: c2r
  id: blocks_complex_to_real
  parameters:
    comment: complex_to_real (drop Q)
  states: {}
- name: gain_out
  id: kyttar_gain
  parameters:
    comment: output gain
    device_id: '"kyttar_0"'
    gain: '1'
  states: {}
- name: snk
  id: kyttar_sink
  parameters:
    comment: chip x16_out (stream 'out')
    device_id: '"kyttar_0"'
    num_channels: '1'
    port_name: '"x16_out"'
    server_host: '"127.0.0.1"'
    server_port: '0'
    stream_id: '"out"'
  states: {}

connections:
- [feedI, '0', srcI, '0']
- [feedQ, '0', srcQ, '0']
- [snk, '0', consumer, '0']
- [srcI, '0', f2c_dual, '0']
- [srcQ, '0', f2c_dual, '1']
- [f2c_dual, '0', mix1, '0']
- [mix1, '0', c2f, '0']
- [c2f, '0', gain_i, '0']
- [c2f, '1', gain_q, '0']
- [gain_i, '0', f2c_single, '0']
- [gain_q, '0', qsink, '0']
- [qsink, '0', qconsumer, '0']
- [nullq, '0', f2c_single, '1']
- [f2c_single, '0', mix2, '0']
- [mix2, '0', c2r, '0']
- [c2r, '0', gain_out, '0']
- [gain_out, '0', snk, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0
